<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>78K0R_Kx3</name>
    <toolchain>
      <name>78000</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>DebuggerProcessorVariant</name>
          <state>0</state>
        </option>
        <option>
          <name>DebuggerCodeModel</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>CRunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CMacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CMacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>MIC78K</state>
        </option>
        <option>
          <name>DDFOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DDFFile</name>
          <state>$TOOLKIT_DIR$\CONFIG\DDF\io78f1166_a0.ddf</state>
        </option>
        <option>
          <name>DebuggerNearConstLocation</name>
          <state>0</state>
        </option>
        <option>
          <name>DDDFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>CSpyExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CSpyExtraOptions</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>EMU78K</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CEmuMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>EmuDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUVerifyLoad</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>IEC78K</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CEmuMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>EmuDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSupExchAdapter</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MIC78K</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CEmuMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>EmuDoLogfile</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIM78K</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CSimMandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>TKS78K</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CEmuMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>EmuDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuComPort</name>
          <version>0</version>
          <state>2</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
  <configuration>
    <name>78K0R_Kx3L</name>
    <toolchain>
      <name>78000</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>DebuggerProcessorVariant</name>
          <state>0</state>
        </option>
        <option>
          <name>DebuggerCodeModel</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>CRunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CMacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CMacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>MIC78K</state>
        </option>
        <option>
          <name>DDFOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DDFFile</name>
          <state>$TOOLKIT_DIR$\CONFIG\DDF\io78f1009_64.ddf</state>
        </option>
        <option>
          <name>DebuggerNearConstLocation</name>
          <state>0</state>
        </option>
        <option>
          <name>DDDFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>CSpyExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CSpyExtraOptions</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>EMU78K</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CEmuMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>EmuDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUVerifyLoad</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>IEC78K</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CEmuMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>EmuDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSupExchAdapter</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MIC78K</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CEmuMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>EmuDoLogfile</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIM78K</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CSimMandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>TKS78K</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CEmuMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>EmuDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuComPort</name>
          <version>0</version>
          <state>2</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
</project>


