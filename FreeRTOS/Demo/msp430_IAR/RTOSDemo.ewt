<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>Demo Source</name>
    <file>
      <name>$PROJ_DIR$\..\Common\Minimal\comtest.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Common\Minimal\flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\portable\MemMang\heap_1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Common\Minimal\integer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\ParTest\ParTest.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Common\Minimal\PollQ.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\serial\serial.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\serial\serialASM.s43</name>
    </file>
  </group>
  <group>
    <name>FreeRTOS Source</name>
    <file>
      <name>$PROJ_DIR$\..\..\Source\croutine.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\portable\IAR\MSP430\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\portable\IAR\MSP430\portext.s43</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\tasks.c</name>
    </file>
  </group>
</project>


