# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8n.h
  General.OGChipSelectEditMenu: LM3Sx9xx Luminary LM3Sx9xx
  ICCARM.CCDefines: IAR_ARMCM3_LM; PACK_STRUCT_END=
  ICCARM.CCDiagSuppress: pa082, pe513, pe167, pe550, pe144, pe191, pe177, pa039, pa050
  ICCARM.CCIncludePath2: ; LuminaryDrivers; ..\common\include; ..\..\source\include; webserver; ..\Common\ethernet\uIP\uip-1.0\uip
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: 
  XLINK.XclFile: RTOSDemo.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  XLINK.XclFile: lnk0t.xcl
  group Demo files
    ../Common/Minimal/: BlockQ.c blocktim.c death.c flash.c integer.c PollQ.c semtest.c
    ./: main.c timertest.c
    ParTest/: ParTest.c
  group Library files
    LuminaryDrivers/: driverlib.r79 osram128x64x4.c
  group Scheduler files
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group System files
    ./: startup_ewarm.c
  group uIP files
    webserver/: emac.c http-strings.c httpd-cgi.c httpd-fs.c httpd.c uIP_Task.c
    ../Common/ethernet/uIP/uip-1.0/uip/: psock.c timer.c uip.c uip_arp.c
