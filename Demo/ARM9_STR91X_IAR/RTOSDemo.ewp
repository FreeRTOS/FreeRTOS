# IAR project RTOSDemo.ewp, settings and files
configuration THUMB (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: STR912 ST STR912
  ICCARM.CCDefines: STR91X_IAR; DEBUG; DONT_RUN_TASK_IN_ARM_MODE_; PACK_STRUCT_END=; ALIGN_STRUCT_END=; STACK_UIP
  ICCARM.CCDiagSuppress: pe191,pa082, pe144, pe550, pe513, pe167, pe177, pa039
  ICCARM.CCIncludePath2: ; library\include\; ..\common\include; ..\..\source\include; STCode; ..\Common\ethernet\uIP\uip-1.0\uip; webserver
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: __REMAP_PREEMPTIVE_TICK_FUNC_
  AARM.AUserIncludes: ..\..\Source\portable\IAR\STR91x
  XLINK.XclFile: lnkarm_flash.xcl
configuration ARM - uIP - D (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: STR91X_IAR; DEBUG; _RUN_TASK_IN_ARM_MODE_; PACK_STRUCT_END=; ALIGN_STRUCT_END=; STACK_UIP
  AARM.ADefines: __REMAP_PREEMPTIVE_TICK_FUNC_; STACK_UIP
configuration ARM - lwIP - D (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: STR91X_IAR; DEBUG; _RUN_TASK_IN_ARM_MODE_; STACK_LWIP
  ICCARM.CCDiagSuppress: pe191,pa082, pe144, pe550, pe513, pe167, pe177
  ICCARM.CCIncludePath2: ; library\include\; ..\common\include; ..\..\source\include; STCode; ..\common\ethernet\lwip\include; ..\common\ethernet\lwip\include\ipv4; ..\common\ethernet\lwip\include\lwip; ..\common\ethernet\lwip\include\netif; ..\common\ethernet\lwip\include\ipv4\lwip; lwip\include\lwIPWebServer; lwip\include
  AARM.ADefines: __REMAP_PREEMPTIVE_TICK_FUNC_; STACK_LWIP
configuration ARM - lwIP - R (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: STR91X_IAR; _RUN_TASK_IN_ARM_MODE_; STACK_LWIP
  ICCARM.CCDiagSuppress: pe191,pa082, pe144, pe550, pe513, pe167, pe177
  ICCARM.CCIncludePath2: as above
  AARM.ADefines: STACK_LWIP
configuration ARM - uIP - R (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: STR91X_IAR; _RUN_TASK_IN_ARM_MODE_; PACK_STRUCT_END=; ALIGN_STRUCT_END=; STACK_UIP
  AARM.ADefines: __REMAP_PREEMPTIVE_TICK_FUNC_; STACK_UIP
  group Demo Source
    ../Common/Minimal/: BlockQ.c comtest.c dynamic.c flash.c flop.c GenQTest.c integer.c PollQ.c QPeek.c semtest.c
    ../../Source/portable/MemMang/: heap_2.c
    STCode/: lcd.c
    ./: main.c
    ParTest/: ParTest.c
    serial/: serial.c
    webserver/: uIP_Task.c
  group Library Source
    Library/include/: 91x_conf.h
    Library/source/: 91x_enet.c 91x_fmi.c 91x_gpio.c 91x_it.c 91x_lib.c 91x_scu.c 91x_tim.c 91x_uart.c 91x_vic.c 91x_wdg.c
  group lwIP/api
    ../Common/ethernet/lwIP/api/: api_lib.c api_msg.c err.c sockets.c tcpip.c
    lwip/api/: sys_arch.c
  group lwIP/core
    ../Common/ethernet/lwIP/core/: dhcp.c inet.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group lwIP/ipv4
    ../Common/ethernet/lwIP/core/ipv4/: icmp.c ip.c ip_addr.c ip_frag.c
  group lwIP/netif
    ../Common/ethernet/lwIP/netif/: etharp.c
    lwip/netif/: ethernetif.c
  group lwIP/snmp
    ../Common/ethernet/lwIP/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group lwIP/WebServer
    lwip/lwipWebServer/: BasicWEB.c fs.c httpd.c
  group RTOS Source
    ./: FreeRTOSConfig.h
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/STR91x/: port.c portasm.s79
  group System Files
    ./: 91x_init_IAR.s 91x_vect_IAR.s lnkarm_flash.xcl lnkarm_ram.xcl
  group uIP
    ../Common/ethernet/uIP/uip-1.0/apps/webserver/: http-strings.c
    webserver/: httpd-cgi.c httpd-fs.c httpd.c
    ../Common/ethernet/uIP/uip-1.0/uip/: psock.c timer.c uip.c uip_arp.c
