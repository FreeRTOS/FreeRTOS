# IAR project RTOSDemo.ewp, settings and files
configuration RAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7S721000 Renesas R7S721000
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NOR_DEBUG
  ICCARM.CCDiagSuppress: Pa082, Pe191
  ICCARM.CCIncludePath2: board\; modules\; ..\Source; ..\Source\Full-Demo; ..\Source\RenesasFiles\include; ..\Source\RenesasFiles\include\iodefines; ..\..\..\Source\include; ..\..\..\Source\portable\IAR\ARM_CA9; ..\..\Common\include; ..\..\..\..\FreeRTOS-Plus\Source\FreeRTOS-Plus-FAT-SL\api; ..\..\..\..\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Source; ..\..\..\Source\portable\IAR\ARM_CA9
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: r7s721000.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Source/: FreeRTOS_tick_config.c FreeRTOSConfig.h LEDs.c main.c
    ./: LowLevelInitialise.c
  group Blinky-Demo
    ../Source/Blinky-Demo/: main_blinky.c
  group board
    board/: board.h
  group FreeRTOS-Source
    ../../../Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS-Source/include
    ../../../Source/include/: FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS-Source/portable/IAR/ARM_CA9
    ../../../Source/portable/IAR/ARM_CA9/: port.c portASM.h portASM.s portmacro.h
  group FreeRTOS-Source/portable/MemMang
    ../../../Source/portable/MemMang/: heap_4.c
  group Full-Demo
    ../Source/Full-Demo/: File-releated-CLI-commands.c File-system-demo.c main_full.c reg_test.s Sample-CLI-commands.c serial.c UARTCommandConsole.c
  group Full-Demo/Common-Demo-Source
    ../../Common/Minimal/: BlockQ.c blocktim.c comtest.c countsem.c death.c dynamic.c flop.c GenQTest.c QueueOverwrite.c recmutex.c semtest.c TimerDemo.c
  group Full-Demo/FreeRTOS-Plus-CLI
    ../../../../FreeRTOS-Plus/Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
  group Full-Demo/FreeRTOS-Plus-FAT-SL/API
    ../../../../FreeRTOS-Plus/Source/FreeRTOS-Plus-FAT-SL/api/: api_mdriver.h api_mdriver_ram.h fat_sl.h
  group Full-Demo/FreeRTOS-Plus-FAT-SL/Common
    ../../../../FreeRTOS-Plus/Source/FreeRTOS-Plus-FAT-SL/fat_sl/common/: dir.c drv.c f_lock.c fat.c file.c util.c util_sfn.c volume.c
  group Full-Demo/FreeRTOS-Plus-FAT-SL/Media-Driver
    ../../../../FreeRTOS-Plus/Source/FreeRTOS-Plus-FAT-SL/media-drv/ram/: ramdrv_f.c
  group Full-Demo/FreeRTOS-Plus-FAT-SL/rtc
    ../../../../FreeRTOS-Plus/Source/FreeRTOS-Plus-FAT-SL/psp/target/rtc/: psp_rtc.c
  group IAR-Files
    modules/: armv7a_cp15_drv.c
  group Renesas-Files
    ./: cstartup.s
  group Renesas-Files/include
    ../Source/RenesasFiles/include/: iodefine.h
  group Renesas-Files/Initialisation and Drivers
    ../Source/RenesasFiles/drivers/common/common_driver/: bsc.c
    ../Source/RenesasFiles/drivers/common/userdef/: bsc_userdef.c
    ../Source/RenesasFiles/drivers/intc/intc_driver/: intc.c intc_handler.c
    ../Source/RenesasFiles/drivers/intc/userdef/: intc_userdef.c
    ../Source/RenesasFiles/drivers/ostm/ostm_driver/: ostm.c
    ../Source/RenesasFiles/board_settings/: peripheral_init_basic.c port_init.c siochar.c stb_init.c
    ../Source/RenesasFiles/drivers/scif_uart/scif_uart_driver/: scif_uart.c
    ../Source/RenesasFiles/drivers/scif_uart/userdef/: scif_uart_userdef.c
