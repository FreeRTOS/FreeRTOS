<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>RX</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>4</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>ODebuggerCore</name>
          <state>0</state>
        </option>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>DebuggerProcessorVariant</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>CRunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CMacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CMacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>RXEMUE20</state>
        </option>
        <option>
          <name>DDFOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DDFFile</name>
          <state>$TOOLKIT_DIR$\config\debugger\ior5f562n8.ddf</state>
        </option>
        <option>
          <name>DebuggerUseExtraOptions</name>
          <state>0</state>
        </option>
        <option>
          <name>DebuggerExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>ODebuggerDoubleSize</name>
          <state>1</state>
        </option>
        <option>
          <name>OCImagesSuppressCheck1</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath1</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck2</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath2</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck3</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath3</name>
          <state></state>
        </option>
        <option>
          <name>ODebuggerByteOrder</name>
          <state>0</state>
        </option>
        <option>
          <name>ODebuggerIntSize</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>RXEMUE20</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>EmuMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>OCEmuUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadSuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadVerifyAll</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>RXJLINK</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>JlinkMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>OCJlinkUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCJlinkUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>OCJlinkDownloadSuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCJlinkDownloadVerifyAll</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMRX</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>SimMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>SimEnablePSP</name>
          <state>0</state>
        </option>
        <option>
          <name>SimPspOverrideConfig</name>
          <state>0</state>
        </option>
        <option>
          <name>SimPspConfigFile</name>
          <state>$TOOLKIT_DIR$\CONFIG\iocf.psp.config</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\FreeRTOS\FreeRTOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\OpenRTOS\OpenRTOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\SymList\SymList.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
  <configuration>
    <name>Blinky</name>
    <toolchain>
      <name>RX</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>4</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>ODebuggerCore</name>
          <state>0</state>
        </option>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>DebuggerProcessorVariant</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CMacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CMacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>RXEMUE20</state>
        </option>
        <option>
          <name>DDFOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DDFFile</name>
          <state>$TOOLKIT_DIR$\config\debugger\ior5f562n8.ddf</state>
        </option>
        <option>
          <name>DebuggerUseExtraOptions</name>
          <state>0</state>
        </option>
        <option>
          <name>DebuggerExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>ODebuggerDoubleSize</name>
          <state>1</state>
        </option>
        <option>
          <name>OCImagesSuppressCheck1</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath1</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck2</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath2</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck3</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath3</name>
          <state></state>
        </option>
        <option>
          <name>ODebuggerByteOrder</name>
          <state>0</state>
        </option>
        <option>
          <name>ODebuggerIntSize</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>RXEMUE20</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>EmuMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>OCEmuUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadSuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadVerifyAll</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>RXJLINK</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>JlinkMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>OCJlinkUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCJlinkUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>OCJlinkDownloadSuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCJlinkDownloadVerifyAll</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMRX</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>SimMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>SimEnablePSP</name>
          <state>0</state>
        </option>
        <option>
          <name>SimPspOverrideConfig</name>
          <state>0</state>
        </option>
        <option>
          <name>SimPspConfigFile</name>
          <state>$TOOLKIT_DIR$\CONFIG\iocf.psp.config</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\FreeRTOS\FreeRTOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\OpenRTOS\OpenRTOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\SymList\SymList.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
  <configuration>
    <name>Debug-with-optimisation</name>
    <toolchain>
      <name>RX</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>4</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>ODebuggerCore</name>
          <state>0</state>
        </option>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>DebuggerProcessorVariant</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>CRunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CMacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CMacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>RXEMUE20</state>
        </option>
        <option>
          <name>DDFOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DDFFile</name>
          <state>$TOOLKIT_DIR$\config\debugger\ior5f562n8.ddf</state>
        </option>
        <option>
          <name>DebuggerUseExtraOptions</name>
          <state>0</state>
        </option>
        <option>
          <name>DebuggerExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>ODebuggerDoubleSize</name>
          <state>1</state>
        </option>
        <option>
          <name>OCImagesSuppressCheck1</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath1</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck2</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath2</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck3</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath3</name>
          <state></state>
        </option>
        <option>
          <name>ODebuggerByteOrder</name>
          <state>0</state>
        </option>
        <option>
          <name>ODebuggerIntSize</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>RXEMUE20</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>EmuMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>OCEmuUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadSuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadVerifyAll</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>RXJLINK</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>JlinkMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>OCJlinkUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCJlinkUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>OCJlinkDownloadSuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCJlinkDownloadVerifyAll</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMRX</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>SimMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>SimEnablePSP</name>
          <state>0</state>
        </option>
        <option>
          <name>SimPspOverrideConfig</name>
          <state>0</state>
        </option>
        <option>
          <name>SimPspConfigFile</name>
          <state>$TOOLKIT_DIR$\CONFIG\iocf.psp.config</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\FreeRTOS\FreeRTOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\OpenRTOS\OpenRTOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\SymList\SymList.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
</project>


