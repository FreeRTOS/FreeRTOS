# Keil uVision project RTOSDemo.uvproj, settings and files
target RTOSDemo (ARM-ADS)
  device: XMC4500 Infineon
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0C000000-0x0C0FFFFF) IROM2(0x08000000-0x080FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: RTOSDemo
  c flags: Optim=1
  c define: rvkdm PART_XMC4500
  c misc: --cpu Cortex-M4.fp --no_allow_fpreg_for_nonfpdata
  c include: ..\CORTEX_M4F_Infineon_XMC4500_Keil;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM4F;..\Common\include
  library: MicroLIB
  memory RVCT4: ROM 0xc000000 size 0x100000
  memory RVCT5: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --entry=Reset_Handler
  group Startup
    ./: startup_XMC4500.s System_XMC4500.c
  group Demo_Source
    ./: main.c FreeRTOSConfig.h RegTest.c main_full.c main_blinky.c
  group FreeRTOS_Source
    ../../Source/: timers.c list.c queue.c tasks.c
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/RVDS/ARM_CM4F/: port.c
  group Other
    ./: readme.txt
  group Common_Demo_Source
    ../Common/Minimal/: semtest.c sp_flop.c BlockQ.c blocktim.c countsem.c death.c dynamic.c GenQTest.c integer.c PollQ.c recmutex.c
