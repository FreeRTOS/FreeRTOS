<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\CORTEX_M0+_LPC51U68_IAR.ewp</path>
    </project>
    <batchBuild />
</workspace>
