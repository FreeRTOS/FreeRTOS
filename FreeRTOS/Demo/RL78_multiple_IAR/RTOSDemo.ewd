<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>3</fileVersion>
    <configuration>
        <name>YRPBRL78G13</name>
        <toolchain>
            <name>RL78</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>1</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>DebugMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugProcessorVariant</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerNearConstLocation</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugRunToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugRunToName</name>
                    <state>main</state>
                </option>
                <option>
                    <name>DebugMacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugMacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>DynDriver</name>
                    <state>TKRL78</state>
                </option>
                <option>
                    <name>DebugDDFOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugDDFFile</name>
                    <state>$TOOLKIT_DIR$\config\debugger\ior5f100le.ddf</state>
                </option>
                <option>
                    <name>DebugCUseExtraOptions</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath1</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset1</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesUse1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesUse3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerDoubleSize</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E1RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E1Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E1DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E1UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E2RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E2UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E20RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E20Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E20DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E20UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E2LiteRL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2LiteMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2LiteDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E2LiteUseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteCollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>EZCRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>EZCubeMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>EZCubeDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>IECRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>IecMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>IecDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecSupExchAdapter</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>SIMRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>SimMandatory</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>TKRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>TKMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>TKDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <debuggerPlugins>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\OpenRTOS\OpenRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\SafeRTOS\SafeRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-III\uCOS-III-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
                <loadFlag>1</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\uCProbe\uCProbePlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
        </debuggerPlugins>
    </configuration>
    <configuration>
        <name>YRPBRL78G14</name>
        <toolchain>
            <name>RL78</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>1</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>DebugMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugProcessorVariant</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerNearConstLocation</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugRunToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugRunToName</name>
                    <state>main</state>
                </option>
                <option>
                    <name>DebugMacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugMacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>DynDriver</name>
                    <state>TKRL78</state>
                </option>
                <option>
                    <name>DebugDDFOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugDDFFile</name>
                    <state>$TOOLKIT_DIR$\config\debugger\ior5f104le.ddf</state>
                </option>
                <option>
                    <name>DebugCUseExtraOptions</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath1</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset1</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesUse1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesUse3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerDoubleSize</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E1RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E1Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E1DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E1UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E2RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E2UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E20RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E20Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E20DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E20UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E2LiteRL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2LiteMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2LiteDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E2LiteUseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteCollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>EZCRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>EZCubeMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>EZCubeDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>IECRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>IecMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>IecDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecSupExchAdapter</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>SIMRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>SimMandatory</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>TKRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>TKMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>TKDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <debuggerPlugins>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\OpenRTOS\OpenRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\SafeRTOS\SafeRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-III\uCOS-III-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
                <loadFlag>1</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\uCProbe\uCProbePlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
        </debuggerPlugins>
    </configuration>
    <configuration>
        <name>YRDKRL78G14</name>
        <toolchain>
            <name>RL78</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>1</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>DebugMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugProcessorVariant</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerNearConstLocation</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugRunToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugRunToName</name>
                    <state>main</state>
                </option>
                <option>
                    <name>DebugMacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugMacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>DynDriver</name>
                    <state>TKRL78</state>
                </option>
                <option>
                    <name>DebugDDFOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugDDFFile</name>
                    <state>$TOOLKIT_DIR$\config\debugger\ior5f104pj.ddf</state>
                </option>
                <option>
                    <name>DebugCUseExtraOptions</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath1</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset1</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesUse1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesUse3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerDoubleSize</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E1RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E1Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E1DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E1UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E2RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E2UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E20RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E20Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E20DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E20UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E2LiteRL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2LiteMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2LiteDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E2LiteUseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteCollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>EZCRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>EZCubeMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>EZCubeDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>IECRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>IecMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>IecDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecSupExchAdapter</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>SIMRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>SimMandatory</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>TKRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>TKMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>TKDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <debuggerPlugins>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\OpenRTOS\OpenRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\SafeRTOS\SafeRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-III\uCOS-III-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
                <loadFlag>1</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\uCProbe\uCProbePlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
        </debuggerPlugins>
    </configuration>
    <configuration>
        <name>RSKRL78G1C</name>
        <toolchain>
            <name>RL78</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>1</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>DebugMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugProcessorVariant</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerNearConstLocation</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugRunToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugRunToName</name>
                    <state>main</state>
                </option>
                <option>
                    <name>DebugMacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugMacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>DynDriver</name>
                    <state>E1RL78</state>
                </option>
                <option>
                    <name>DebugDDFOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugDDFFile</name>
                    <state>$TOOLKIT_DIR$\config\debugger\ior5f10jgc.ddf</state>
                </option>
                <option>
                    <name>DebugCUseExtraOptions</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath1</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset1</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesUse1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesUse3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerDoubleSize</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E1RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E1Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E1DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E1UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E2RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E2UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E20RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E20Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E20DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E20UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E2LiteRL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2LiteMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2LiteDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E2LiteUseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteCollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>EZCRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>EZCubeMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>EZCubeDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>IECRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>IecMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>IecDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecSupExchAdapter</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>SIMRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>SimMandatory</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>TKRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>TKMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>TKDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <debuggerPlugins>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\OpenRTOS\OpenRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\SafeRTOS\SafeRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-III\uCOS-III-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
                <loadFlag>1</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\uCProbe\uCProbePlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
        </debuggerPlugins>
    </configuration>
    <configuration>
        <name>RSKRL78L13</name>
        <toolchain>
            <name>RL78</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>1</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>DebugMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugProcessorVariant</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerNearConstLocation</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugRunToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugRunToName</name>
                    <state>main</state>
                </option>
                <option>
                    <name>DebugMacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugMacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>DynDriver</name>
                    <state>E1RL78</state>
                </option>
                <option>
                    <name>DebugDDFOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugDDFFile</name>
                    <state>$TOOLKIT_DIR$\config\debugger\ior5f10wmg.ddf</state>
                </option>
                <option>
                    <name>DebugCUseExtraOptions</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath1</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset1</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesUse1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesUse3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerDoubleSize</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E1RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E1Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E1DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E1UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E2RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E2UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E20RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E20Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E20DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E20UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E2LiteRL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2LiteMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2LiteDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E2LiteUseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteCollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>EZCRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>EZCubeMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>EZCubeDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>IECRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>IecMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>IecDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecSupExchAdapter</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>SIMRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>SimMandatory</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>TKRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>TKMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>TKDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <debuggerPlugins>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\OpenRTOS\OpenRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\SafeRTOS\SafeRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-III\uCOS-III-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
                <loadFlag>1</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\uCProbe\uCProbePlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
        </debuggerPlugins>
    </configuration>
    <configuration>
        <name>RSKRL78L1C</name>
        <toolchain>
            <name>RL78</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>1</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>DebugMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugProcessorVariant</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerNearConstLocation</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugRunToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugRunToName</name>
                    <state>main</state>
                </option>
                <option>
                    <name>DebugMacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugMacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>DynDriver</name>
                    <state>E1RL78</state>
                </option>
                <option>
                    <name>DebugDDFOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugDDFFile</name>
                    <state>$TOOLKIT_DIR$\config\debugger\ior5f110pj.ddf</state>
                </option>
                <option>
                    <name>DebugCUseExtraOptions</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath1</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset1</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesUse1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesUse3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerDoubleSize</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E1RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E1Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E1DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E1UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E2RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E2UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E20RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E20Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E20DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E20UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E2LiteRL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2LiteMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2LiteDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E2LiteUseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteCollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>EZCRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>EZCubeMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>EZCubeDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>IECRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>IecMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>IecDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecSupExchAdapter</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>SIMRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>SimMandatory</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>TKRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>TKMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>TKDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <debuggerPlugins>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\OpenRTOS\OpenRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\SafeRTOS\SafeRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-III\uCOS-III-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
                <loadFlag>1</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\uCProbe\uCProbePlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
        </debuggerPlugins>
    </configuration>
    <configuration>
        <name>QB_R5F10ELE_TB</name>
        <toolchain>
            <name>RL78</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>1</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>DebugMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugProcessorVariant</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerNearConstLocation</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugRunToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebugRunToName</name>
                    <state>main</state>
                </option>
                <option>
                    <name>DebugMacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugMacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>DynDriver</name>
                    <state>E1RL78</state>
                </option>
                <option>
                    <name>DebugDDFOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugDDFFile</name>
                    <state>$TOOLKIT_DIR$\config\debugger\ior5f10ele.ddf</state>
                </option>
                <option>
                    <name>DebugCUseExtraOptions</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath1</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset1</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>DebugImagesUse1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebugImagesUse3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerDoubleSize</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E1RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E1Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E1DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E1UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E1CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E2RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E2UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E20RL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E20Mandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20SuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20VerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E20DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20SerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E20UseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20CollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>E2LiteRL78</name>
            <archiveVersion>11</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2LiteMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2LiteDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>E2LiteUseSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteCollectData</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>EZCRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>EZCubeMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>EZCubeLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>EZCubeDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>IECRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>IecMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>IecDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>IecSupExchAdapter</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>SIMRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>SimMandatory</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>TKRL78</name>
            <archiveVersion>10</archiveVersion>
            <data>
                <version>0</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>TKMandatory</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKSuppressLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKVerifyLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>TKLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>TKDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <debuggerPlugins>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\OpenRTOS\OpenRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\SafeRTOS\SafeRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-III\uCOS-III-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
                <loadFlag>1</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\uCProbe\uCProbePlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
        </debuggerPlugins>
    </configuration>
</project>
