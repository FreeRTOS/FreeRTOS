# IAR project at91sam9xe-ek.ewp, settings and files
configuration at91sam9xe128_flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: at91sam9xe128 Atmel at91sam9xe128
  ICCARM.CCDefines: at91sam9xe128; flash; SAM9XE_IAR
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\..\Common\drivers\Atmel\at91lib; ..\..\Common\drivers\Atmel\at91lib\boards\at91sam9xe-ek; ..\..\Common\drivers\Atmel\at91lib\peripherals; ..\..\Common\drivers\Atmel\at91lib\components; ..\..\Common\drivers\Atmel\at91lib\usb; ..\..\..\Source\include; ..; ..\..\Common\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: at91sam9xe128; flash
  AARM.AUserIncludes: ..\..\Common\drivers\Atmel\at91lib; ..\..\Common\drivers\Atmel\at91lib\peripherals; ..\..\Common\drivers\Atmel\at91lib\boards\at91sam9xe-ek; ..\..\..\Source\portable\IAR\AtmelSAM9XE
  OBJCOPY.OOCOutputFile: at91sam9xe128_flash.bin
  ILINK.IlinkOutputFile: at91sam9xe128_flash.out
  ILINK.IlinkIcfFile: ..\..\Common\drivers\Atmel\at91lib\boards\at91sam9xe-ek\at91sam9xe128\flash.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration at91sam9xe128_sdram (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: at91sam9xe128; sdram
  OBJCOPY.OOCOutputFile: at91sam9xe128_sdram.bin
  ILINK.IlinkOutputFile: at91sam9xe128_sdram.out
  ILINK.IlinkIcfFile: ..\..\Common\drivers\Atmel\at91lib\boards\at91sam9xe-ek\at91sam9xe128\sdram.icf
configuration at91sam9xe128_sram (ARM, debug)
  as the first configuration, except:
  AARM.ADefines: at91sam9xe128; sram
  OBJCOPY.OOCOutputFile: at91sam9xe128_sram.bin
  ILINK.IlinkOutputFile: at91sam9xe128_sram.out
  ILINK.IlinkIcfFile: ..\..\Common\drivers\Atmel\at91lib\boards\at91sam9xe-ek\at91sam9xe128\sram.icf
configuration at91sam9xe256_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam9xe256 Atmel at91sam9xe256
  AARM.ADefines: at91sam9xe256; flash
  OBJCOPY.OOCOutputFile: at91sam9xe256_flash.bin
  ILINK.IlinkOutputFile: at91sam9xe256_flash.out
  ILINK.IlinkIcfFile: ..\..\Common\drivers\Atmel\at91lib\boards\at91sam9xe-ek\at91sam9xe256\flash.icf
configuration at91sam9xe256_sdram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam9xe256 Atmel at91sam9xe256
  AARM.ADefines: at91sam9xe256; sdram
  OBJCOPY.OOCOutputFile: at91sam9xe256_sdram.bin
  ILINK.IlinkOutputFile: at91sam9xe256_sdram.out
  ILINK.IlinkIcfFile: ..\..\Common\drivers\Atmel\at91lib\boards\at91sam9xe-ek\at91sam9xe256\sdram.icf
configuration at91sam9xe256_sram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam9xe256 Atmel at91sam9xe256
  AARM.ADefines: at91sam9xe256; sram
  OBJCOPY.OOCOutputFile: at91sam9xe256_sram.bin
  ILINK.IlinkOutputFile: at91sam9xe256_sram.out
  ILINK.IlinkIcfFile: ..\..\Common\drivers\Atmel\at91lib\boards\at91sam9xe-ek\at91sam9xe256\sram.icf
configuration at91sam9xe512_flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam9xe512 Atmel at91sam9xe512
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\Common\drivers\Atmel\at91lib; ..\..\Common\drivers\Atmel\at91lib\boards\at91sam9xe-ek; ..\..\Common\drivers\Atmel\at91lib\peripherals; ..\..\Common\drivers\Atmel\at91lib\components; ..\..\Common\drivers\Atmel\at91lib\utility; ..\..\Common\drivers\Atmel\at91lib\usb; ..\..\..\Source\include; ..; ..\..\Common\include
  AARM.ADefines: at91sam9xe512; flash
  OBJCOPY.OOCOutputFile: at91sam9xe512_flash.bin
  ILINK.IlinkOutputFile: at91sam9xe512_flash.out
  ILINK.IlinkIcfFile: ..\..\Common\drivers\Atmel\at91lib\boards\at91sam9xe-ek\at91sam9xe512\flash.icf
configuration at91sam9xe512_sdram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam9xe512 Atmel at91sam9xe512
  AARM.ADefines: at91sam9xe512; sdram
  OBJCOPY.OOCOutputFile: at91sam9xe512_sdram.bin
  ILINK.IlinkOutputFile: at91sam9xe512_sdram.out
  ILINK.IlinkIcfFile: ..\..\Common\drivers\Atmel\at91lib\boards\at91sam9xe-ek\at91sam9xe512\sdram.icf
configuration at91sam9xe512_sram (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: at91sam9xe512 Atmel at91sam9xe512
  AARM.ADefines: at91sam9xe512; sram
  OBJCOPY.OOCOutputFile: at91sam9xe512_sram.bin
  ILINK.IlinkOutputFile: at91sam9xe512_sram.out
  ILINK.IlinkIcfFile: ..\..\Common\drivers\Atmel\at91lib\boards\at91sam9xe-ek\at91sam9xe512\sram.icf
  group (top)
    ../: main.c
    ../ParTest/: ParTest.c
  group at91lib/boards/at91sam9xe-ek
    ../../Common/drivers/Atmel/at91lib/boards/at91sam9xe-ek/: board.h board_cstartup_iar.s board_lowlevel.c board_memories.c board_memories.h
  group at91lib/boards/at91sam9xe-ek/at91sam9xe128
    ../../Common/drivers/Atmel/at91lib/boards/at91sam9xe-ek/at91sam9xe128/: AT91SAM9XE128.h flash.icf sdram.icf sram.icf
  group at91lib/boards/at91sam9xe-ek/at91sam9xe256
    ../../Common/drivers/Atmel/at91lib/boards/at91sam9xe-ek/at91sam9xe256/: AT91SAM9XE256.h flash.icf sdram.icf sram.icf
  group at91lib/boards/at91sam9xe-ek/at91sam9xe512
    ../../Common/drivers/Atmel/at91lib/boards/at91sam9xe-ek/at91sam9xe512/: AT91SAM9XE512.h flash.icf sdram.icf sram.icf
  group at91lib/peripherals/aic
    ../../Common/drivers/Atmel/at91lib/peripherals/aic/: aic.c aic.h
  group at91lib/peripherals/dbgu
    ../../Common/drivers/Atmel/at91lib/peripherals/dbgu/: dbgu.c dbgu.h
  group at91lib/peripherals/pio
    ../../Common/drivers/Atmel/at91lib/peripherals/pio/: pio.c pio.h pio_it.c pio_it.h
  group at91lib/peripherals/pit
    ../../Common/drivers/Atmel/at91lib/peripherals/pit/: pit.c pit.h
  group at91lib/peripherals/tc
    ../../Common/drivers/Atmel/at91lib/peripherals/tc/: tc.c tc.h
  group at91lib/utility
    ../../Common/drivers/Atmel/at91lib/utility/: assert.h led.c led.h trace.h
  group resources
    ../../../resources/: at91sam9xe-ek-flash.mac at91sam9xe-ek-sdram.mac at91sam9xe-ek-sram.mac
  group scheduler_source
    ../../../Source/portable/MemMang/: heap_3.c
    ../../../Source/: list.c queue.c tasks.c
    ../../../Source/portable/IAR/AtmelSAM9XE/: port.c portasm.s79
  group standard_demo_source
    ../../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c flash.c GenQTest.c integer.c PollQ.c QPeek.c recmutex.c semtest.c
