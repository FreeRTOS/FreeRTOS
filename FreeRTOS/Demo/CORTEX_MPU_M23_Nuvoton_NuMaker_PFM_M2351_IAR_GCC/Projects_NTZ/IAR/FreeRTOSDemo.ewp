# IAR project FreeRTOSDemo.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2351 series Nuvoton M2351 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 60
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: Config; ..\..\Nuvoton_Code\StdDriver\inc; ..\..\Nuvoton_Code\CMSIS\Include; ..\..\Nuvoton_Code\Device\Nuvoton\M2351\Include; ..\..\..\..\Source\include; ..\..\..\..\Source\portable\IAR\ARM_CM23_NTZ\non_secure; ..\..\..\Common\ARMv8M\mpu_demo; ..\..\..\Common\ARMv8M\reg_tests\IAR\ARM_CM23\non_secure; ..\..\RegTests
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: configENABLE_FPU=0; configENABLE_MPU=1; configENABLE_TRUSTZONE=0
  AARM.AUserIncludes: Config
  OBJCOPY.OOCOutputFile: FreeRTOSDemo.bin
  ILINK.IlinkOutputFile: FreeRTOSDemo.out
  ILINK.IlinkIcfFile: FreeRTOSDemo.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Config
    Config/: FreeRTOSConfig.h
  group Demos
    ../../../Common/ARMv8M/mpu_demo/: mpu_demo.c mpu_demo.h
    ../../../Common/ARMv8M/reg_tests/IAR/ARM_CM23/non_secure/: reg_test_asm.h reg_test_asm.s
  group Device
    ../../Nuvoton_Code/Device/Nuvoton/M2351/Source/IAR/: startup_M2351.s
    ../../Nuvoton_Code/Device/Nuvoton/M2351/Source/: system_M2351.c
  group Drivers
    ../../Nuvoton_Code/StdDriver/src/: clk.c gpio.c retarget.c
  group FreeRTOS
    ../../../../Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/portable/Common
    ../../../../Source/portable/Common/: mpu_wrappers.c
  group FreeRTOS/portable/IAR/ARM_CM23_NTZ
    ../../../../Source/portable/IAR/ARM_CM23_NTZ/non_secure/: port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group FreeRTOS/portable/MemMang
    ../../../../Source/portable/MemMang/: heap_4.c
  group User
    ./: fault_handler.s main.c
    ../../RegTests/: reg_tests.c reg_tests.h
