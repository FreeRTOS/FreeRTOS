# IAR project RTOSDemo.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: HIFIVE1 SiFive HiFive1 Rev B
  General.GHeapSize: 0x0
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 0
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCIncludePath2: $PROJ_DIR$; ..\..\Source\include; ..\..\Source\portable\IAR\RISC-V; ..\..\Source\portable\IAR\RISC-V\chip_specific_extensions\RV32I_CLINT_no_extensions; ..\Common\include
  IASMRISCV.AsmIncludePath: ..\..\Source\portable\IAR\RISC-V\chip_specific_extensions\RV32I_CLINT_no_extensions
  OBJCOPY.OOCOutputFile: RTOSDemo.bin
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  General.GDeviceSelect: RV32 RV32
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCDefines: NDEBUG
  group (top)
    ./: FreeRTOSConfig.h main.c
  group blinky_demo
    blinky_demo/: main_blinky.c
  group FreeRTOS_source
    ../../Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_source/include
    ../../Source/include/: event_groups.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
  group FreeRTOS_source/portable
    ../../Source/portable/IAR/RISC-V/: port.c portASM.s
  group FreeRTOS_source/portable/memmang
    ../../Source/portable/MemMang/: heap_4.c
  group full_demo
    full_demo/: main_full.c RegTest.s
  group full_demo/common
    ../Common/Minimal/: blocktim.c dynamic.c TaskNotify.c TimerDemo.c
