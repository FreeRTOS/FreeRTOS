# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7S910018_R4F Renesas R7S910018_R4F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: System\IAR\inc; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CRx_No_GIC; src; src\cg_src; ..\Common\include; src\Full_Demo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: src
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: System\IAR\RZ_T1_init.icf
  ILINK.IlinkProgramEntryLabel: loader_init1
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    src/: FreeRTOS_tick_config.c FreeRTOSConfig.h main.c
    System/IAR/: Interrupt_Entry_Stubs.asm
    src/cg_src/: r_cg_cgc.c r_cg_mpc.c
  group Blinky Demo
    src/Blinky_Demo/: main_blinky.c
  group FreeRTOS_Source
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/portable/MemMang
    ../../Source/portable/MemMang/: heap_4.c
  group FreeRTOS_Source/portable/MemMang/IAR
    ../../Source/portable/IAR/ARM_CRx_No_GIC/: port.c portASM.s portmacro.h
  group Full_Demo
    src/Full_Demo/: IntQueueTimer.c main_full.c reg_test_IAR.asm
  group Full_Demo/Common Demo Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c comtest.c countsem.c death.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c IntQueue.c IntSemTest.c QueueOverwrite.c recmutex.c semtest.c TaskNotify.c TimerDemo.c
  group Renesas_cg_src
    src/cg_src/: r_cg_cgc_user.c r_cg_cmt_user.c r_cg_icu.c r_cg_icu_user.c r_cg_intprg.c r_cg_port.c r_cg_port_user.c r_cg_rspi.c r_cg_rspi_user.c r_cg_systeminit.c r_cg_tpu.c r_cg_tpu_user.c
  group System
    System/IAR/src/: exit.c loader_init.asm loader_init2.c r_atcm_init.c r_cpg.c r_ecm.c r_icu_init.c r_ram_init.c r_reset.c vector.asm
