# IAR project rtosdemo.ewp, settings and files
configuration V850ESJx3 (V850, debug)
  General.GMemoryModel: 1
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl85esnn.h
  General.GHeapSize: 4096
  General.GDeviceSelect: 70F3746 V850ES - uPD70F3746
  ICCV850.CCDefines: __IAR_V850ES_Jx3__
  ICCV850.CCDiagSuppress: Pa082
  ICCV850.CCIncludePath2: ..\..\Source\include; ..\Common\include; LEDtoggle; IntV850ES; $PROJ_DIR$
  ICCV850.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCV850.CCOptLevel: 0
  ICCV850.CCOptStrategy: 1
  AV850.ADefines: CODE_MODEL_PIC; DATA_MODEL_TINY
  AV850.OAIncludePath2: $PROJ_DIR$; ..\..\Source\portable\IAR\V850ES_Fx3
  AV850.OAStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk70f3746.xcl
  XLINK.XlinkStackSize: 1
configuration V850ESFx3 (V850, debug)
  as the first configuration, except:
  General.GDeviceSelect: 70F3385 V850ES - uPD70F3385
  ICCV850.CCDefines: __IAR_V850ES_Fx3__
  AV850.OAIncludePath2: $PROJ_DIR$; ..\..\Source\portable\IAR\V850ES
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk70f3385.xcl
configuration V850ESJx3L (V850, debug)
  as the first configuration, except:
  General.GDeviceSelect: 70F3738 V850ES - uPD70F3738
  ICCV850.CCDefines: __IAR_V850ES_Jx3_L__
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk70f3738.xcl
configuration V850ESJx2 (V850, debug)
  as the first configuration, except:
  General.GDeviceSelect: 70F3717 V850ES - uPD70F3717
  ICCV850.CCDefines: __IAR_V850ES_Jx2__
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk70f3738.xcl
configuration V850ESHx2 (V850, debug)
  as the first configuration, except:
  General.GDeviceSelect: 70F3707 V850ES - uPD70F3707
  ICCV850.CCDefines: __IAR_V850ES_Hx2__
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk70f3281y.xcl
  group demo source
    ./: main.c RegTest.s85
    serial/: serial.c serialISR.s85
  group demo source/LEDs
    ParTest/: ParTest_Fx3_App_Board.c ParTest_Generic_Target_Board.c
  group demo source/Low Level Init
    LowLevelInit/: LowLevelInit.c LowLevelInit_Fx3.c LowLevelInit_Hx2.c
  group demo source/Standard Demo Tasks
    ../Common/Minimal/: BlockQ.c comtest.c death.c flash.c GenQTest.c PollQ.c QPeek.c recmutex.c semtest.c
  group kernel source
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/V850ES/: port.c
  group kernel source/device specific
    ../../Source/portable/IAR/V850ES/: portasm.s85 portasm_Fx3.s85 portasm_Hx2.s85
