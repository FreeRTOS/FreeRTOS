# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMV71Q21 Atmel ATSAMV71Q21
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: __SAMV71Q21__; sram; TRACE_LEVEL=4
  ICCARM.CCIncludePath2: libboard_samv7-ek; libchip_samv7; libchip_samv7\include\samv7; $PROJ_DIR$; Full_Demo; ..\Common\include; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM7\r0p1
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; sram; __ASSEMBLY__
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTOSDemo.bin
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: libboard_samv7-ek\resources\IAR\samv71q21_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group (top)
    ./: main.c
  group Atmel_LibBoard
    libboard_samv7-ek/source/: board_lowlevel.c board_memories.c led.c
    libboard_samv7-ek/resources/IAR/: startup_sam.c
    libboard_samv7-ek/resources/: system_sam.c
  group Atmel_LibChip
    libchip_samv7/source/: pio.c pmc.c supc.c tc.c wdt.c
  group Blinky_Demo
    Blinky_Demo/: main_blinky.c
  group FreeRTOS_Source
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/portable
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s portmacro.h
  group Full_Demo
    Full_Demo/: IntQueueTimer.c IntQueueTimer.h main_full.c RegTest.s
  group Full_Demo/Common_Demo_Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c IntQueue.c IntSemTest.c QueueOverwrite.c QueueSet.c recmutex.c semtest.c TaskNotify.c TimerDemo.c
