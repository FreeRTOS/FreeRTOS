# Keil uVision project RTOSDemo_Keil.uvproj, settings and files
target Blinky (ARM-ADS)
  device: MB9AF314L Fujitsu Semiconductors
  cpu: IRAM(0x20000000-0x20003FFF) IRAM2(0x1FFFC000-0x1FFFFFFF) IROM(0x00000000-0x0003FFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: RTOSDemo_Keil
  c flags: Optim=1
  c include: .\Fujitu_source;..\Common\include;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM3;.
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x8000
  group Fujitsu Source
    ./Fujitu_source/: core_cm3.c system_mb9af31x.c
    ./Fujitu_source/startup_keil/: startup_mb9af31x.s
  group Common_Demo_Source
    ../Common/Minimal/: TimerDemo.c BlockQ.c blocktim.c comtest.c countsem.c death.c dynamic.c flash.c GenQTest.c PollQ.c QPeek.c recmutex.c semtest.c
  group FreeRTOS_Source
    ../../Source/: timers.c list.c queue.c tasks.c
    ../../Source/portable/RVDS/ARM_CM3/: port.c
    ../../Source/portable/MemMang/: heap_2.c
  group Demo_Source
    ./: serial.c main_blinky.c main-full.c ParTest.c
target Full (ARM-ADS)
  device: MB9AF314L Fujitsu Semiconductors
  cpu: as above
  output: RTOSDemo_Keil
  c flags: Optim=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x8000
target Full_with_optimisation (ARM-ADS)
  device: MB9AF314L Fujitsu Semiconductors
  cpu: as above
  output: RTOSDemo_Keil
  c flags: Optim=4
  c include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffc000 size 0x8000
