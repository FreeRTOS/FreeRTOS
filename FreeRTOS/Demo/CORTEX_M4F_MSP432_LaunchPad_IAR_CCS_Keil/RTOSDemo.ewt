<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>DriverLibrary</name>
    <file>
      <name>$PROJ_DIR$\driverlib\cpu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\driverlib\cs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\driverlib\fpu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\driverlib\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\driverlib\interrupt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\driverlib\pcm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\driverlib\timer32.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\driverlib\uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\driverlib\wdt_a.c</name>
    </file>
  </group>
  <group>
    <name>FreeRTOS_Source</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\..\Source\include\event_groups.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Source\include\FreeRTOS.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Source\include\projdefs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Source\include\queue.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Source\include\semphr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Source\include\task.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Source\include\timers.h</name>
      </file>
    </group>
    <group>
      <name>Portable</name>
      <group>
        <name>IAR</name>
        <group>
          <name>Cortex-M4F</name>
          <file>
            <name>$PROJ_DIR$\..\..\Source\portable\IAR\ARM_CM4F\port.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\Source\portable\IAR\ARM_CM4F\portasm.s</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\Source\portable\IAR\ARM_CM4F\portmacro.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>MemMang</name>
        <file>
          <name>$PROJ_DIR$\..\..\Source\portable\MemMang\heap_4.c</name>
        </file>
      </group>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\Source\event_groups.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\timers.c</name>
    </file>
  </group>
  <group>
    <name>Full_Demo</name>
    <group>
      <name>FreeRTOS+CLI</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI\FreeRTOS_CLI.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI\FreeRTOS_CLI.h</name>
      </file>
    </group>
    <group>
      <name>Standard Demo Tasks</name>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\BlockQ.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\countsem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\EventGroupsDemo.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\GenQTest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\IntQueue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\IntSemTest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\recmutex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\semtest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\sp_flop.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\TaskNotify.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\TimerDemo.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\Full_Demo\IntQueueTimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Full_Demo\main_full.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Full_Demo\RegTest.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Full_Demo\RunTimeStatsTimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\FreeRTOS-Plus\Demo\Common\FreeRTOS_Plus_CLI_Demos\Sample-CLI-commands.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Full_Demo\serial.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\FreeRTOS-Plus\Demo\Common\FreeRTOS_Plus_CLI_Demos\UARTCommandConsole.c</name>
    </file>
  </group>
  <group>
    <name>Simply Blinky Demo</name>
    <file>
      <name>$PROJ_DIR$\SimplyBlinkyDemo\main_blinky.c</name>
    </file>
  </group>
  <group>
    <name>System</name>
    <file>
      <name>$PROJ_DIR$\system\IAR\msp432_startup_ewarm.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\FreeRTOSConfig.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
</project>


