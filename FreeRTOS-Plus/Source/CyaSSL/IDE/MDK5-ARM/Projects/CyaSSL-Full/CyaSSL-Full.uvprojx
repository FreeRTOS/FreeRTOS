# Keil uVision project CyaSSL-Full.uvprojx, settings and files
target CyaSSL-Full (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(120000000) ELITTLE
  output: CyaSSL-Full
  c flags: Optim=4
  c define: HAVE_CONFIG_H  MDK_CONF_CYASSL
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: benchmark.c client.c echoclient.c echoserver.c server.c cert_data.c test.c main.c shell.c
  group Configuration
    ./RTE/wolfSSL/: config-CyaSSL.h config-Crypt.h settings.h
    ./RTE/Network/: Net_Config_ETH_0.h
  group Documentation
    ./: Abstract.txt
  group Devices
    ./: time-CortexM3-4.c time-dummy.c
  group ::CMSIS
    RTE/CMSIS/: RTX_Conf_CM.c
    C:/Keil5/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM3.lib
  group ::Device
    RTE/Device/STM32F207IG/: RTE_Device.h startup_stm32f2xx.s system_stm32f2xx.c
    C:/Keil5/ARM/PACK/Keil/STM32F2xx_DFP/1.0.7/RTE_Driver/: DMA_STM32F2xx.c GPIO_STM32F2xx.c
  group ::Drivers
    C:/Keil5/ARM/PACK/Keil/MDK-Middleware/5.1.4/Network/Driver/: PHY_ST802RT1.c
    C:/Keil5/ARM/PACK/Keil/STM32F2xx_DFP/1.0.7/RTE_Driver/: EMAC_STM32F2xx.c MCI_STM32F2xx.c
  group ::File System
    RTE/File_System/: FS_Config.c FS_Config_MC_0.h
    C:/Keil5/ARM/PACK/Keil/MDK-Middleware/5.1.4/FileSystem/Lib/ARM/: FS_LFN_CM3_L.lib
  group ::Network
    RTE/Network/: Net_Config.c Net_Config_BSD.h Net_Config_DNS_Client.h Net_Config_ETH_0.h Net_Config_TCP.h Net_Config_UDP.h Net_Debug.c
    C:/Keil5/ARM/PACK/Keil/MDK-Middleware/5.1.4/Network/Lib/ARM/: Net_Dbg_CM3_L.lib
  group ::wolfSSL
    RTE/wolfSSL/: config-Crypt.h config-CyaSSL.h settings.h
    C:/Keil5/ARM/PACK/wolfSSL/CyaSSL/3.0.0/cyassl/IDE/MDK5-ARM/Src/: cyassl_MDK_ARM.c
    C:/Keil5/ARM/PACK/wolfSSL/CyaSSL/3.0.0/cyassl/ctaocrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c coding.c compress.c des3.c dh.c dsa.c ecc.c ecc_fp.c error.c hc128.c hmac.c integer.c logging.c md2.c md4.c md5.c memory.c misc.c wc_port.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c tfm.c
    C:/Keil5/ARM/PACK/wolfSSL/CyaSSL/3.0.0/cyassl/src/: crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, File System:CORE 5.0.5, File System:Drive:Memory Card 5.0.5, Network:CORE 5.0.4, Network:Interface:ETH 5.0.4, Network:Service:DNS Client 5.0.4, Network:Socket:BSD 5.0.4, Network:Socket:TCP 5.0.4, Network:Socket:UDP 5.0.4, Device:DMA 1.0.0, Device:GPIO 1.0.0, Device:Startup 1.0.0, Drivers:Ethernet MAC 1.02.0, Drivers:Ethernet PHY:ST802RT1 5.01.0, Drivers:MCI 1.01.0, wolfSSL:CyaSSL:Core 3.0.0, wolfSSL:wolfCrypt:CORE 3.0.0
