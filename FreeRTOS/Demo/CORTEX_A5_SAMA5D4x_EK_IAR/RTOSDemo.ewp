# IAR project RTOSDemo.ewp, settings and files
configuration sram (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: sama5d4x; sram; TRACE_LEVEL=0
  ICCARM.CCDiagSuppress: Pa131, Pa039
  ICCARM.CCIncludePath2: AtmelFiles/libboard_sama5d4x-ek; AtmelFiles/libchip_sama5d4x; AtmelFiles/libchip_sama5d4x/include; AtmelFiles\usb\device; AtmelFiles\usb\include; .; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CA5_No_GIC; ..\Common\include; ..\..\..\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI; Full_Demo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: sama5d4x; sram
  AARM.AUserIncludes: .
  OBJCOPY.OOCOutputFile: sram.bin
  ILINK.IlinkOutputFile: sram.out
  ILINK.IlinkIcfFile: AtmelFiles\libboard_sama5d4x-ek\resources\ewarm\sama5d4x\sram.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
configuration ddram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: sama5d4x; ddram; TRACE_LEVEL=4
  ICCARM.CCOptLevel: 0
  AARM.ADefines: sama5d4x; ddram
  AARM.AUserIncludes: ..\..\..\libraries; .; ..\..\Source\portable\IAR\ARM_CA5_No_GIC
  OBJCOPY.OOCOutputFile: ddram.bin
  ILINK.IlinkOutputFile: ddram.out
  ILINK.IlinkIcfFile: AtmelFiles\libboard_sama5d4x-ek\resources\ewarm\sama5d4x\ddram.icf
  group (top)
    ./: cstartup_with_FreeRTOS_vectors.s FreeRTOS_tick_config.c FreeRTOSConfig.h LEDs.c main.c
  group Atmel Files/libboard_sama5d4x-ek
    AtmelFiles/libboard_sama5d4x-ek/source/: board_cstartup_iar.s board_lowlevel.c board_memories.c dbg_util.c dbgu_console.c led.c
  group Atmel Files/libchip_sama5d4x
    AtmelFiles/libchip_sama5d4x/source/: aic.c mmu.c pio.c pio_it.c pit.c pmc.c tc.c USBD_HAL.c wdt.c
    AtmelFiles/libchip_sama5d4x/cp15/: cp15.c cp15_asm_iar.s
  group Atmel Files/USB
    AtmelFiles/usb/: USBDDriverDescriptors.c
  group Atmel Files/USB/common/cdc
    AtmelFiles/usb/common/cdc/: CDCLineCoding.c CDCSetControlLineStateRequest.c
  group Atmel Files/USB/common/core
    AtmelFiles/usb/common/core/: USBDescriptors.c USBRequests.c
  group Atmel Files/USB/device/cdc-serial
    AtmelFiles/usb/device/cdc-serial/: CDCDSerial.c CDCDSerial_Callbacks.c CDCDSerialDriver.c CDCDSerialPort.c
  group Atmel Files/USB/device/core
    AtmelFiles/usb/device/core/: USBD.c USBDCallbacks.c USBDDriver.c USBDDriverCallbacks.c
  group Blinky Demo
    Blinky_Demo/: main_blinky.c
  group FreeRTOS Source
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS Source/portable
    ../../Source/portable/IAR/ARM_CA5_No_GIC/: port.c portASM.s
  group FreeRTOS Source/portable/MemMang
    ../../Source/portable/MemMang/: heap_4.c
  group FreeRTOS+CLI
    ../../../FreeRTOS-Plus/Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
  group Full Demo
    ./: CDCCommandConsole.c
    Full_Demo/: IntQueueTimer.c main_full.c reg_test.S
    ../../../FreeRTOS-Plus/Demo/Common/FreeRTOS_Plus_CLI_Demos/: Sample-CLI-commands.c
  group Full Demo/Common Demo Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c IntQueue.c QueueOverwrite.c recmutex.c semtest.c TimerDemo.c
