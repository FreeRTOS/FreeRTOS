<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>1</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>11</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CSVariantProcessor</name>
          <state>0</state>
        </option>
        <option>
          <name>MacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state>$TOOLKIT_DIR$\*.mac</state>
        </option>
        <option>
          <name>DDFile</name>
          <state>$TOOLKIT_DIR$\Config\iom323.ddf</state>
        </option>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>OCEnhancedCore</name>
          <state>1</state>
        </option>
        <option>
          <name>OC64BitDoubles</name>
          <state>1</state>
        </option>
        <option>
          <name>DdfFileSlave</name>
          <state></state>
        </option>
        <option>
          <name>RunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>RunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>newDDFileOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CSVariantEepromSize</name>
          <state>0</state>
        </option>
        <option>
          <name>CSVariant64KFlash</name>
          <state>0</state>
        </option>
        <option>
          <name>CdDllSlave</name>
          <state>0</state>
        </option>
        <option>
          <name>CDynDriver</name>
          <state>SIMAVR</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>CCRAVR</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>OCCRAVRDriver</name>
          <state>1</state>
        </option>
        <option>
          <name>OCCRAVRExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>OCCRAVRExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>OCCRAVRPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OCCRAVRBaud</name>
          <version>0</version>
          <state>5</state>
        </option>
        <option>
          <name>OCCRAVRParity</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OCCRAVRDataBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OCCRAVRStopBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OCCRAVRHandshake</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OCCRAVRAllComm</name>
          <state>1</state>
        </option>
        <option>
          <name>OCCRAVRDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>OCCRAVRLogFile</name>
          <state>cspycomm.log</state>
        </option>
        <option>
          <name>OCCRAVRSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>OCCRAVRFastDownload</name>
          <state>1</state>
        </option>
        <option>
          <name>OCCRAVRTargetCCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>OCCRAVRdownloadToData</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>ICE200AVR</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>OICE200AVRDriver</name>
          <state>1</state>
        </option>
        <option>
          <name>OICE200AVRExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>OICE200AVRExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>OICE200AVRPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OICE200AVRBaud</name>
          <version>0</version>
          <state>5</state>
        </option>
        <option>
          <name>OICE200AVRParity</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OICE200AVRDataBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OICE200AVRStopBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OICE200AVRHandshake</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OICE200AVRAllComm</name>
          <state>1</state>
        </option>
        <option>
          <name>OICE200AVRDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>OICE200AVRLogFile</name>
          <state>cspycomm.log</state>
        </option>
        <option>
          <name>OICE200AVRHighSpeed</name>
          <state>1</state>
        </option>
        <option>
          <name>OICE200AVRSingleStepTimers</name>
          <state>0</state>
        </option>
        <option>
          <name>OICE200AVRRestoreEEPROM</name>
          <state>0</state>
        </option>
        <option>
          <name>OICE200AVRComPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OICE200AVRSuppLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>OICE200AVRConsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>OICE200AVRIce200ResetDelayList</name>
          <version>8</version>
          <state>0</state>
        </option>
        <option>
          <name>OICE200AVRIce200downloadToData</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>JTAGICEAVR</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>OJTAGICEAVRDriver</name>
          <state>1</state>
        </option>
        <option>
          <name>OJTAGICEAVRExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>OJTAGICEAVRExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRBaud</name>
          <version>0</version>
          <state>5</state>
        </option>
        <option>
          <name>OJTAGICEAVRParity</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRDataBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRStopBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRHandshake</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRAllComm</name>
          <state>1</state>
        </option>
        <option>
          <name>OJTAGICEAVRDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRLogFile</name>
          <state>cspycomm.log</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagIceDefaultCom</name>
          <state>1</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagIceComPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagIceSuppLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagIceConsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagIceJtagFreqRadio</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagIceJtagFreqManually</name>
          <state>100000</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagIceJtagFreq</name>
          <version>0</version>
          <state>5</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagIceJtagDeviceBefore</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagIceJtagDeviceAfter</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagIceJtagInstrBitsBefore</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagIceJtagInstrBitsAfter</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagIceDaisyChain</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagDebugTimers</name>
          <state>1</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagDebugEeprom</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagDebugReset</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagDebugFuses</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEAVRJtagIcedownloadToData</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>JTAGICEMKIIAVR</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>3</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>OJTAGICEMKIIAVRDriver</name>
          <state>1</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRBaud</name>
          <version>0</version>
          <state>5</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRParity</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRDataBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRStopBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRHandshake</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRAllComm</name>
          <state>1</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRLogFile</name>
          <state>cspycomm.log</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagIceDefaultCom</name>
          <state>1</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagIceComPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagIceSuppLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagIceConsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagIceJtagFreqRadio</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagIceJtagFreqManually</name>
          <state>100000</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagIceJtagFreq</name>
          <version>0</version>
          <state>8</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagIceJtagDeviceBefore</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagIceJtagDeviceAfter</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagIceJtagInstrBitsBefore</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagIceJtagInstrBitsAfter</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagIceDaisyChain</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagDebugTimers</name>
          <state>1</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagDebugEeprom</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagDebugReset</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagDebugFuses</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagIcedownloadToData</name>
          <state>0</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRCommunication</name>
          <state>1</state>
        </option>
        <option>
          <name>OJTAGICEMKIIAVRJtagSoftwareBreak</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMAVR</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>OSIMAVRDriver</name>
          <state>1</state>
        </option>
        <option>
          <name>OSIMAVRExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>OSIMAVRExtraOptionsCheck</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>THIRDPARTYAVR</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>OTHIRDPARTYAVRDriver</name>
          <state>1</state>
        </option>
        <option>
          <name>OTHIRDPARTYAVRExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>OTHIRDPARTYAVRExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>OTHIRDPARTYAVRDriverDll</name>
          <state>Browse to your Third party driver</state>
        </option>
        <option>
          <name>OTHIRDPARTYAVRSuppress</name>
          <state>0</state>
        </option>
        <option>
          <name>OTHIRDPARTYAVRVerify</name>
          <state>0</state>
        </option>
        <option>
          <name>OTHIRDPARTYAVRLogFileCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>OTHIRDPARTYAVRLogFileEditB</name>
          <state>$TOOLKIT_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Trace\Trace.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
</project>


