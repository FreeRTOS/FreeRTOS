# Keil uVision project FreeRTOS_Demo.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: FT32F072R8ATx FMD
  pack: FMD.FT32F0xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FreeRTOS_Demo +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Source\Driver\inc;.\Source\Tasks\inc;.\Source\User\inc;.\Source\Libraries\CMSIS\FT32F0xx\Include;.\Source\Libraries\FT32F0xx_Driver\Inc;..\..\Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./Source/User/src/: ft32f0xx_it.c main.c
    ./Source/Libraries/CMSIS/FT32F0xx/source/arm/: startup_ft32f072xb.s
  group Driver
    ./Source/Driver/src/: board.c Peripheral.c
  group Tasks
    ./Source/Tasks/src/: HighProTask.c IdleTask.c InitTask.c LowProTask.c TaskManager.c
  group FreeRTOS
    ../../Source/: list.c queue.c tasks.c timers.c
    ../../Source/portable/: heap_4.c port.c
  group Libraris
    ./Source/Libraries/FT32F0xx_Driver/Src/: ft32f0xx_adc.c ft32f0xx_comp.c ft32f0xx_crc.c ft32f0xx_crs.c ft32f0xx_dac.c ft32f0xx_debug.c ft32f0xx_dma.c ft32f0xx_exti.c ft32f0xx_flash.c ft32f0xx_gpio.c ft32f0xx_i2c.c ft32f0xx_iwdg.c ft32f0xx_misc.c ft32f0xx_opa.c ft32f0xx_pwr.c ft32f0xx_rcc.c ft32f0xx_rtc.c ft32f0xx_spi.c ft32f0xx_syscfg.c ft32f0xx_tim.c ft32f0xx_usart.c ft32f0xx_wwdg.c
    ./Source/Libraries/CMSIS/FT32F0xx/source/: system_ft32f0xx.c
