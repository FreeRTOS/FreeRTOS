# Keil uVision project FreeRTOSDemo_s.uvprojx, settings and files
target FreeRTOSDemo_s (6190000::V6.19::ARMCLANG)
  device: M2351KIAAEES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.19
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x00080000) CPUTYPE("ARMV8MBL") TZ CLOCK(12000000) ESEL ELITTLE
  output: FreeRTOSDemo_s
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 v6Lang=5
  c define: DEBUG_PORT = UART0
  c misc: -mfloat-abi=soft -Wno-documentation -Wno-reserved-id-macro
  c include: ..\Config;..\..\Keil;..\..\..\..\Common\ARMv8M\tz_demo;..\..\..\..\..\Source\portable\GCC\ARM_CM23\secure;..\..\..\Nuvoton_Code\StdDriver\inc;..\..\..\Nuvoton_Code\CMSIS\Include;..\..\..\Nuvoton_Code\Device\Nuvoton\M2351\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\FreeRTOSDemo_s.sct
  link misc: --import-cmse-lib-out .\Objects\FreeRTOSDemo_importlib.o
  group Device
    ../../../Nuvoton_Code/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../../../Nuvoton_Code/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
    ../: partition_M2351.h RTE_Components.h
  group Drivers
    ../../../Nuvoton_Code/StdDriver/src/: clk.c gpio.c retarget.c
  group NSCFunctions
    ../../../../Common/ARMv8M/tz_demo/: nsc_functions.h nsc_functions.c
    ../../../../Common/ARMv8M/reg_tests/GCC/ARM_CM23/secure/: secure_reg_test_asm.c secure_reg_test_asm.h
  group SecureContext
    ../../../../../Source/portable/GCC/ARM_CM23/secure/: secure_context.h secure_context.c secure_context_port.c secure_port_macros.h
  group SecureHeap
    ../../../../../Source/portable/GCC/ARM_CM23/secure/: secure_heap.h secure_heap.c
  group SecureInit
    ../../../../../Source/portable/GCC/ARM_CM23/secure/: secure_init.h secure_init.c
  group User
    ./: main_s.c
