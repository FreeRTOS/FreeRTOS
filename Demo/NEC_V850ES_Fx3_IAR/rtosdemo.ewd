<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>V850ESJx3</name>
    <toolchain>
      <name>V850</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>12</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>CProcessor</name>
          <state>0</state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>MICV850</state>
        </option>
        <option>
          <name>GoToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>GoToName</name>
          <state>main</state>
        </option>
        <option>
          <name>MacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>MemOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MemFile</name>
          <state>$TOOLKIT_DIR$\CONFIG\DDF\io70f3746.ddf</state>
        </option>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>DDDFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>CSpyExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CSpyExtraOptions</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>EMUV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>EMUMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSmartStation</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>IECV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>IECMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>IECSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>IECVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>IecDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>IecLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MICV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>MICMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>MICSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>MICVerifyLoad</name>
          <state>1</state>
        </option>
        <option>
          <name>MICEraseFlash</name>
          <state>0</state>
        </option>
        <option>
          <name>MICMINICUBESpeed</name>
          <state>0</state>
        </option>
        <option>
          <name>MicDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>MicLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>MICUseMini2</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>NWIV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>NWIMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>NWISuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>NWIVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>NWIEraseFlash</name>
          <state>0</state>
        </option>
        <option>
          <name>NWINWireSpeed</name>
          <state>1</state>
        </option>
        <option>
          <name>NwiDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>NwiLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>ROMV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>ROMMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMFastDownload</name>
          <state>1</state>
        </option>
        <option>
          <name>ROMSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>Port</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Baud</name>
          <version>0</version>
          <state>7</state>
        </option>
        <option>
          <name>Parity</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>DataBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>StopBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Handshake</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>AllComm</name>
          <state>1</state>
        </option>
        <option>
          <name>DoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>LogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>SIMMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>SIMEnablePipe</name>
          <state>0</state>
        </option>
        <option>
          <name>SIMDisableAlign</name>
          <state>0</state>
        </option>
        <option>
          <name>SIMIllInstr</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>TKSV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>TKSMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>TKSSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>TKSVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>TksDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>TksLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>TksComPort</name>
          <version>0</version>
          <state>2</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\SymList\SymList.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
  <configuration>
    <name>V850ESFx3</name>
    <toolchain>
      <name>V850</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>12</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>CProcessor</name>
          <state>0</state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>MICV850</state>
        </option>
        <option>
          <name>GoToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>GoToName</name>
          <state>main</state>
        </option>
        <option>
          <name>MacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>MemOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MemFile</name>
          <state>$TOOLKIT_DIR$\CONFIG\DDF\io70f3385.ddf</state>
        </option>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>DDDFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>CSpyExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CSpyExtraOptions</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>EMUV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>EMUMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSmartStation</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>IECV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>IECMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>IECSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>IECVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>IecDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>IecLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MICV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>MICMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>MICSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>MICVerifyLoad</name>
          <state>1</state>
        </option>
        <option>
          <name>MICEraseFlash</name>
          <state>0</state>
        </option>
        <option>
          <name>MICMINICUBESpeed</name>
          <state>0</state>
        </option>
        <option>
          <name>MicDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>MicLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>MICUseMini2</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>NWIV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>NWIMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>NWISuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>NWIVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>NWIEraseFlash</name>
          <state>0</state>
        </option>
        <option>
          <name>NWINWireSpeed</name>
          <state>1</state>
        </option>
        <option>
          <name>NwiDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>NwiLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>ROMV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>ROMMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMFastDownload</name>
          <state>1</state>
        </option>
        <option>
          <name>ROMSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>Port</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Baud</name>
          <version>0</version>
          <state>7</state>
        </option>
        <option>
          <name>Parity</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>DataBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>StopBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Handshake</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>AllComm</name>
          <state>1</state>
        </option>
        <option>
          <name>DoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>LogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>SIMMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>SIMEnablePipe</name>
          <state>0</state>
        </option>
        <option>
          <name>SIMDisableAlign</name>
          <state>0</state>
        </option>
        <option>
          <name>SIMIllInstr</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>TKSV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>TKSMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>TKSSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>TKSVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>TksDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>TksLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>TksComPort</name>
          <version>0</version>
          <state>2</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\SymList\SymList.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
  <configuration>
    <name>V850ESJx3L</name>
    <toolchain>
      <name>V850</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>12</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>CProcessor</name>
          <state>0</state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>MICV850</state>
        </option>
        <option>
          <name>GoToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>GoToName</name>
          <state>main</state>
        </option>
        <option>
          <name>MacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>MemOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MemFile</name>
          <state>$TOOLKIT_DIR$\CONFIG\DDF\io70f3738.ddf</state>
        </option>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>DDDFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>CSpyExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CSpyExtraOptions</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>EMUV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>EMUMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSmartStation</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>IECV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>IECMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>IECSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>IECVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>IecDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>IecLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MICV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>MICMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>MICSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>MICVerifyLoad</name>
          <state>1</state>
        </option>
        <option>
          <name>MICEraseFlash</name>
          <state>0</state>
        </option>
        <option>
          <name>MICMINICUBESpeed</name>
          <state>0</state>
        </option>
        <option>
          <name>MicDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>MicLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>MICUseMini2</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>NWIV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>NWIMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>NWISuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>NWIVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>NWIEraseFlash</name>
          <state>0</state>
        </option>
        <option>
          <name>NWINWireSpeed</name>
          <state>1</state>
        </option>
        <option>
          <name>NwiDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>NwiLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>ROMV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>ROMMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMFastDownload</name>
          <state>1</state>
        </option>
        <option>
          <name>ROMSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>Port</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Baud</name>
          <version>0</version>
          <state>7</state>
        </option>
        <option>
          <name>Parity</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>DataBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>StopBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Handshake</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>AllComm</name>
          <state>1</state>
        </option>
        <option>
          <name>DoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>LogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>SIMMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>SIMEnablePipe</name>
          <state>0</state>
        </option>
        <option>
          <name>SIMDisableAlign</name>
          <state>0</state>
        </option>
        <option>
          <name>SIMIllInstr</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>TKSV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>TKSMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>TKSSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>TKSVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>TksDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>TksLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>TksComPort</name>
          <version>0</version>
          <state>2</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\SymList\SymList.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
  <configuration>
    <name>V850ESJx2</name>
    <toolchain>
      <name>V850</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>12</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>CProcessor</name>
          <state>0</state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>MICV850</state>
        </option>
        <option>
          <name>GoToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>GoToName</name>
          <state>main</state>
        </option>
        <option>
          <name>MacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>MemOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MemFile</name>
          <state>$TOOLKIT_DIR$\CONFIG\DDF\io70f3717.ddf</state>
        </option>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>DDDFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>CSpyExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CSpyExtraOptions</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>EMUV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>EMUMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSmartStation</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>IECV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>IECMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>IECSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>IECVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>IecDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>IecLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MICV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>MICMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>MICSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>MICVerifyLoad</name>
          <state>1</state>
        </option>
        <option>
          <name>MICEraseFlash</name>
          <state>0</state>
        </option>
        <option>
          <name>MICMINICUBESpeed</name>
          <state>0</state>
        </option>
        <option>
          <name>MicDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>MicLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>MICUseMini2</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>NWIV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>NWIMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>NWISuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>NWIVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>NWIEraseFlash</name>
          <state>0</state>
        </option>
        <option>
          <name>NWINWireSpeed</name>
          <state>1</state>
        </option>
        <option>
          <name>NwiDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>NwiLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>ROMV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>ROMMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMFastDownload</name>
          <state>1</state>
        </option>
        <option>
          <name>ROMSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>Port</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Baud</name>
          <version>0</version>
          <state>7</state>
        </option>
        <option>
          <name>Parity</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>DataBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>StopBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Handshake</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>AllComm</name>
          <state>1</state>
        </option>
        <option>
          <name>DoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>LogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>SIMMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>SIMEnablePipe</name>
          <state>0</state>
        </option>
        <option>
          <name>SIMDisableAlign</name>
          <state>0</state>
        </option>
        <option>
          <name>SIMIllInstr</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>TKSV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>TKSMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>TKSSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>TKSVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>TksDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>TksLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>TksComPort</name>
          <version>0</version>
          <state>2</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\SymList\SymList.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
  <configuration>
    <name>V850ESHx2</name>
    <toolchain>
      <name>V850</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>12</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>CProcessor</name>
          <state>0</state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>MICV850</state>
        </option>
        <option>
          <name>GoToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>GoToName</name>
          <state>main</state>
        </option>
        <option>
          <name>MacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>MemOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MemFile</name>
          <state>$TOOLKIT_DIR$\CONFIG\DDF\io70f3281y.ddf</state>
        </option>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>DDDFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>CSpyExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CSpyExtraOptions</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>EMUV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>EMUMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>EMUSmartStation</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>IECV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>IECMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>IECSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>IECVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>IecDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>IecLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>MICV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>MICMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>MICSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>MICVerifyLoad</name>
          <state>1</state>
        </option>
        <option>
          <name>MICEraseFlash</name>
          <state>0</state>
        </option>
        <option>
          <name>MICMINICUBESpeed</name>
          <state>0</state>
        </option>
        <option>
          <name>MicDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>MicLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>MICUseMini2</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>NWIV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>NWIMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>NWISuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>NWIVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>NWIEraseFlash</name>
          <state>0</state>
        </option>
        <option>
          <name>NWINWireSpeed</name>
          <state>1</state>
        </option>
        <option>
          <name>NwiDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>NwiLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>ROMV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>ROMMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMFastDownload</name>
          <state>1</state>
        </option>
        <option>
          <name>ROMSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>ROMVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>Port</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Baud</name>
          <version>0</version>
          <state>7</state>
        </option>
        <option>
          <name>Parity</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>DataBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>StopBits</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>Handshake</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>AllComm</name>
          <state>1</state>
        </option>
        <option>
          <name>DoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>LogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>SIMMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>SIMEnablePipe</name>
          <state>0</state>
        </option>
        <option>
          <name>SIMDisableAlign</name>
          <state>0</state>
        </option>
        <option>
          <name>SIMIllInstr</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>TKSV850</name>
      <archiveVersion>5</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>TKSMandatory</name>
          <state>0</state>
        </option>
        <option>
          <name>TKSSuppressLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>TKSVerifyLoad</name>
          <state>0</state>
        </option>
        <option>
          <name>TksDoLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>TksLogFile</name>
          <state>$PROJ_DIR$\cspycomm.log</state>
        </option>
        <option>
          <name>TksComPort</name>
          <version>0</version>
          <state>2</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\SymList\SymList.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
</project>


