# IAR project RTOSDemo_IAR.ewp, settings and files
configuration Blinky (ARM, debug)
  General.OGChipSelectEditMenu: A2F200M3F Actel A2F200M3F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ../../Source/include; ../../Source/portable/IAR/ARM_CM3; $PROJ_DIR$; MicroSemi_Code/CMSIS; MicroSemi_Code/drivers/mss_gpio; MicroSemi_Code/drivers/mss_watchdog
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTOSDemo_IAR.srec
  ILINK.IlinkOutputFile: RTOSDemo_IAR.out
  ILINK.IlinkIcfFile: IAR_System\linker_nvm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Full (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDiagSuppress: Pa082, Pe1644, Pa039, Pa050, pe191
  ICCARM.CCIncludePath2: ../../Source/include; ../../Source/portable/IAR/ARM_CM3; $PROJ_DIR$; MicroSemi_Code/CMSIS; MicroSemi_Code/drivers/mss_gpio; MicroSemi_Code/drivers/mss_watchdog; MicroSemi_Code/drivers/mss_ace; MicroSemi_Code/drivers_config/mss_ace; WebServer; ../Common/ethernet/FreeTCPIP/apps/httpd; ../Common/ethernet/FreeTCPIP; ../Common/ethernet/FreeTCPIP/net; ../Common/include; MicroSemi_Code/drivers/I2C; MicroSemi_Code/drivers/mss_ethernet_mac; MicroSemi_Code/drivers/mss_timer; MicroSemi_Code/drivers/OLED
configuration Full_with_optimisation (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDiagSuppress: Pa082, Pe1644, Pa039, Pa050, pe191
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main-blinky.c main-full.c ParTest.c printf-stdarg.c uIP_Task.c
  group Common_Demo_Source
    ../Common/Minimal/: BlockQ.c blocktim.c death.c dynamic.c flash.c GenQTest.c QPeek.c recmutex.c semtest.c TimerDemo.c
  group FreeRTOS_Source
    ../../Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/Portable
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group FreeTCPIP(based on uIP)
    ../Common/ethernet/FreeTCPIP/: psock.c timer.c uip.c uip_arp.c
  group Microsemi_Source/CMSIS
    MicroSemi_Code/CMSIS/: core_cm3.c system_a2fxxxm3.c
  group Microsemi_Source/Drivers
    MicroSemi_Code/drivers_config/mss_ace/: ace_config.c
    MicroSemi_Code/drivers/mss_ace/: ace_convert.c mss_ace.c
    MicroSemi_Code/drivers/mss_ethernet_mac/: crc32.c mss_ethernet_mac.c phy.c
    MicroSemi_Code/drivers/I2C/: i2c.c
    MicroSemi_Code/drivers/mss_gpio/: mss_gpio.c
    MicroSemi_Code/drivers/OLED/: oled.c
  group Microsemi_Source/Startup
    MicroSemi_Code/CMSIS/startup_iar/: startup_a2fxxxm3.s
  group Web_Server
    ../Common/ethernet/FreeTCPIP/apps/httpd/: http-strings.c httpd-fs.c httpd.c
    WebServer/: httpd-cgi.c
