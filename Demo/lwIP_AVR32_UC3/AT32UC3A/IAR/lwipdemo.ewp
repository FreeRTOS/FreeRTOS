# IAR project lwipdemo.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allaf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x1000
  General.GHeapSize: 0x7000
  ICCAVR32.CCDefines: BOARD=EVK1100; HTTP_USED=1; SMTP_USED=0; TFTP_USED=1; FREERTOS_USED=1
  ICCAVR32.CCDiagSuppress: Pe191, Pa082, Pe236, Pe171
  ICCAVR32.CCIncludePath2: ..\..\UTILS\; ..\..\UTILS\PREPROCESSOR\; ..\..\BOARDS\; ..\..\DRIVERS\INTC\; ..\..\DRIVERS\TC\; ..\..\DRIVERS\USART\; ..\..\DRIVERS\PM\; ..\..\DRIVERS\MACB\; ..\..\DRIVERS\GPIO\; ..\..\DRIVERS\FLASHC\; ..\..\..\..\Source\include\; ..\..\..\Common\include\; ..\..\NETWORK\; ..\..\NETWORK\BasicWEB\; ..\..\NETWORK\BasicSMTP\; ..\..\NETWORK\BasicTFTP\; ..\..\NETWORK\lwip-port\AT32UC3A\; ..\..\NETWORK\lwip-port\AT32UC3A\IAR\; ..\..\..\Common\ethernet\lwIP\include\; ..\..\..\Common\ethernet\lwIP\include\ipv4\; ..\..\..\..\Source\portable\IAR\AVR32_UC3\; ..\..\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 0
  ICCAVR32.CCOptStrategy: 0
  AAVR32.AIncludePaths: ..\..\UTILS\; ..\..\UTILS\PREPROCESSOR\; ..\..\DRIVERS\INTC\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\UTILS\LINKER_SCRIPTS\AT32UC3A\0512\IAR\lnkuc3a0512.xcl
  group (top)
    ../../: main.c
    ../../PARTEST/: ParTest.c
    ../../SERIAL/: serial.c
  group DLIB
    ../../../../Source/portable/IAR/AVR32_UC3/: read.c write.c
    ../../SERVICES/USB/CLASS/DFU/EXAMPLES/ISP/BOOT/: trampoline.s82
  group Drivers
    ../../DRIVERS/FLASHC/: flashc.c
    ../../DRIVERS/GPIO/: gpio.c
    ../../DRIVERS/INTC/: intc.c
    ../../BOARDS/EVK1100/: led.c
    ../../DRIVERS/MACB/: macb.c
    ../../DRIVERS/PM/: pm.c
    ../../DRIVERS/TC/: tc.c
    ../../DRIVERS/USART/: usart.c
  group FreeRTOS
    ../../../Common/Minimal/: flash.c
  group FreeRTOS/AVR32_UC3
    ../../../../Source/portable/IAR/AVR32_UC3/: exception.s82 port.c
  group FreeRTOS/Source
    ../../../../Source/portable/MemMang/: heap_3.c
    ../../../../Source/: list.c queue.c tasks.c
  group NETWORK/lwip
    ../../../Common/ethernet/lwIP/api/: api_lib.c api_msg.c err.c sockets.c tcpip.c
    ../../../Common/ethernet/lwIP/netif/: etharp.c
    ../../NETWORK/lwip-port/AT32UC3A/: ethernetif.c sys_arch.c
    ../../../Common/ethernet/lwIP/core/ipv4/: icmp.c ip.c ip_addr.c ip_frag.c
    ../../../Common/ethernet/lwIP/core/: inet.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group NETWORK/Services
    ../../NETWORK/BasicSMTP/: BasicSMTP.c
    ../../NETWORK/BasicTFTP/: BasicTFTP.c
    ../../NETWORK/BasicWEB/: BasicWEB.c
    ../../NETWORK/: ethernet.c
