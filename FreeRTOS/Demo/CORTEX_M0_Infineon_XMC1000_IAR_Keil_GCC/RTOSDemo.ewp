# IAR project RTOSDemo.ewp, settings and files
configuration XMC1200 Boot Kit (ARM, debug)
  General.OGChipSelectEditMenu: XMC1200-T038x0200 Infineon XMC1200-T038x0200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: .; CMSIS; IAR_Specific; ..\common\include; ..\..\source\include; ..\..\source\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$.\
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration XMC1100 Boot Kit (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: XMC1100-T038x0064 Infineon XMC1100-T038x0064
configuration XMC1300 Boot Kit (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: XMC1100-T038x0064 Infineon XMC1100-T038x0064
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  group (top)
    ./: main-blinky.c main-full.c main.c ParTest_XMC1100.c ParTest_XMC1200.c ParTest_XMC1300.c
    IAR_Specific/: RegTest_IAR.s
  group Common Demo Source
    ../Common/Minimal/: blocktim.c countsem.c dynamic.c QueueOverwrite.c QueueSet.c recmutex.c
  group FreeRTOS Source
    ../../Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS Source/portable
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group System
    IAR_Specific/: startup_XMC1100.s startup_XMC1200.s startup_XMC1300.s system_XMC1100.c system_XMC1200.c system_XMC1300.c
