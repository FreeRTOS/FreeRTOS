# IAR project rtosdemo.ewp, settings and files
configuration Debug (V850, debug)
  General.GMemoryModel: 1
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl85esnn.h
  General.GHeapSize: 4096
  General.GDeviceSelect: 70F3385 V850ES - uPD70F3385
  ICCV850.CCDefines: __IAR_V850ES_Fx3__
  ICCV850.CCDiagSuppress: Pa082
  ICCV850.CCIncludePath2: ..\..\Source\include; ..\Common\include; LEDtoggle; IntV850ES; $PROJ_DIR$
  ICCV850.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCV850.CCOptLevel: 0
  ICCV850.CCOptStrategy: 1
  AV850.ADefines: CODE_MODEL_PIC; DATA_MODEL_TINY
  AV850.OAIncludePath2: $PROJ_DIR$
  AV850.OAStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk70f3385.xcl
  XLINK.XlinkStackSize: 1
configuration Release (V850)
  as the first configuration, except:
  General.GMemoryModel: 0
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl85-tnn.h
  General.GDeviceSelect: UnspecifiedV850 V850 - Unspecified
  ICCV850.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk85.xcl
  group demo source
    ../Common/Full/: integer.c PollQ.c print.c
    LEDtoggle/: LED.c
    ./: main.c RegTest.s85
    ../: semtest.c
  group kernel source
    ../../Source/portable/MemMang/: heap_1.c
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/V850ES_Fx3/: port.c portmacro.s85
