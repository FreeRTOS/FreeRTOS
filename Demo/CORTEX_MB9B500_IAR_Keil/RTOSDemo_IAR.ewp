# IAR project RTOSDemo_IAR.ewp, settings and files
configuration Blinky (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506N Fujitsu MB9BF506N
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: Fujitu_source; $PROJ_DIR$; ../../Source/include; ../../Source/portable/IAR/ARM_CM3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTOSDemo_IAR.srec
  ILINK.IlinkOutputFile: RTOSDemo_IAR.out
  ILINK.IlinkIcfFile: config\mb9bf506_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main_blinky.c
  group FreeRTOS_Source
    ../../Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/Portable
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Fujitsu_Source
    Fujitu_source/: core_cm3.c system_mb9bf50x.c
    Fujitu_source/startup_iar/: startup_mb9bf50x.s
