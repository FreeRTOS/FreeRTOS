# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR730 ST STR730
  ICCARM.CCDefines: STR75X_IAR
  ICCARM.CCDiagSuppress: Pa082, Pe191
  ICCARM.CCIncludePath2: STLibrary\inc; Demo\include; ..\..\source\include; ..\common\include; $PROJ_DIR$
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: ..\..\Source\portable\IAR\STR75x
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: STR75x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group Demo Source
    ../Common/Minimal/: BlockQ.c blocktim.c comtest.c dynamic.c flash.c integer.c
    ../../Source/portable/MemMang/: heap_2.c
    STLibrary/src/: lcd.c
    ./: main.c
    ParTest/: ParTest.c
    serial/: serial.c
  group Library Source
    STLibrary/src/: 75x_cfg.c 75x_eic.c 75x_gpio.c 75x_it.c 75x_lib.c 75x_mrcc.c 75x_tb.c 75x_uart.c
  group RTOS Source
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/STR75x/: port.c portasm.s79
  group startup
    ./: 75x_init.s 75x_vect.s
