<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>3</fileVersion>
    <configuration>
        <name>Debug</name>
        <toolchain>
            <name>RX</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>5</archiveVersion>
            <data>
                <version>6</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>CMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebuggerProcessorVariant</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CRunToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CRunToName</name>
                    <state>Processing_Before_Start_Kernel</state>
                </option>
                <option>
                    <name>CMacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CMacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>DynDriver</name>
                    <state>RXE2LITE</state>
                </option>
                <option>
                    <name>DDFOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DDFFile</name>
                    <state>$TOOLKIT_DIR$\config\debugger\ior5f572nn.ddf</state>
                </option>
                <option>
                    <name>DebuggerUseExtraOptions</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>ODebuggerByteOrder</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODebuggerDoubleSize</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>ODebuggerCore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODebuggerIntSize</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCImagesOffset1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesUse1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODebuggerPatch</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODebuggerFpu</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>RXEMUE20</name>
            <archiveVersion>5</archiveVersion>
            <data>
                <version>6</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>EmuMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCDownloadSuppressDownload</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCDownloadVerifyAll</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCDebuggingMode</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCExcecuteAfterFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCDownloadOnlyChangedBlocks</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E20DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCEmuSerialNo2</name>
                    <state>Automatic</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>RXE2</name>
            <archiveVersion>2</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2Mandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>E2DownloadSuppressDownload</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2DownloadVerifyAll</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2DebuggingMode</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2DownloadExcecuteAfterFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2DownloadOnlyChangedBlocks</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SerialNo2</name>
                    <state>Automatic</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>RXE2LITE</name>
            <archiveVersion>2</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>E2LiteMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>E2LiteDownloadSuppressDownload</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteDownloadVerifyAll</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteDebuggingMode</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteDownloadExcecuteAfterFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteDownloadOnlyChangedBlocks</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2LiteDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSerialNo2</name>
                    <state>Automatic</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>RXJLINK</name>
            <archiveVersion>4</archiveVersion>
            <data>
                <version>6</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>JlinkMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCJlinkDownloadSuppressDownload</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkDownloadVerifyAll</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCDebuggingMode</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkExcecuteAfterFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkScanChainEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkDevicePosition</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkOtherDeviceTypes</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkPreceedingIRBits</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkUseUSBSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkUSBSerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>JLinkLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>JLinkDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>SIMRX</name>
            <archiveVersion>1</archiveVersion>
            <data>
                <version>3</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>SimMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>SimHaveTfu</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <debuggerPlugins>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\OpenRTOS\OpenRTOSPlugin.ewplugin</file>
                <loadFlag>1</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\RemedyRtosViewer\RemedyRtosViewer.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\SafeRTOS\SafeRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\ThreadX\ThreadXRxPlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-III\uCOS-III-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\TargetAccessServer\TargetAccessServer.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\uCProbe\uCProbePlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
        </debuggerPlugins>
    </configuration>
    <configuration>
        <name>Release</name>
        <toolchain>
            <name>RX</name>
        </toolchain>
        <debug>0</debug>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>5</archiveVersion>
            <data>
                <version>6</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>CMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DebuggerProcessorVariant</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CRunToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CRunToName</name>
                    <state>main</state>
                </option>
                <option>
                    <name>CMacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CMacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>DynDriver</name>
                    <state>SIMRX</state>
                </option>
                <option>
                    <name>DDFOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DDFFile</name>
                    <state></state>
                </option>
                <option>
                    <name>DebuggerUseExtraOptions</name>
                    <state>0</state>
                </option>
                <option>
                    <name>DebuggerExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>ODebuggerByteOrder</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODebuggerDoubleSize</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>ODebuggerCore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODebuggerIntSize</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCImagesOffset1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesUse1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODebuggerPatch</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODebuggerFpu</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>RXEMUE20</name>
            <archiveVersion>5</archiveVersion>
            <data>
                <version>6</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>EmuMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCDownloadSuppressDownload</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCDownloadVerifyAll</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCDebuggingMode</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCExcecuteAfterFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCDownloadOnlyChangedBlocks</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E20LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E20DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCEmuSerialNo2</name>
                    <state>Automatic</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>RXE2</name>
            <archiveVersion>2</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>E2Mandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>E2DownloadSuppressDownload</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2DownloadVerifyAll</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2DebuggingMode</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2DownloadExcecuteAfterFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2DownloadOnlyChangedBlocks</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2SerialNo2</name>
                    <state>Automatic</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>RXE2LITE</name>
            <archiveVersion>2</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>E2LiteMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>E2LiteDownloadSuppressDownload</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteDownloadVerifyAll</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteDebuggingMode</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteDownloadExcecuteAfterFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteDownloadOnlyChangedBlocks</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>E2LiteDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>E2LiteSerialNo2</name>
                    <state>Automatic</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>RXJLINK</name>
            <archiveVersion>4</archiveVersion>
            <data>
                <version>6</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>JlinkMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCJlinkDownloadSuppressDownload</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkDownloadVerifyAll</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCDebuggingMode</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkExcecuteAfterFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkScanChainEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkDevicePosition</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkOtherDeviceTypes</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkPreceedingIRBits</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkUseUSBSerialNo</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCJlinkUSBSerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>JLinkLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>JLinkDoLogfile</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>SIMRX</name>
            <archiveVersion>1</archiveVersion>
            <data>
                <version>3</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>SimMandatory</name>
                    <state>1</state>
                </option>
                <option>
                    <name>SimHaveTfu</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <debuggerPlugins>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\OpenRTOS\OpenRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\RemedyRtosViewer\RemedyRtosViewer.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\SafeRTOS\SafeRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\ThreadX\ThreadXRxPlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-III\uCOS-III-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\TargetAccessServer\TargetAccessServer.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\uCProbe\uCProbePlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
        </debuggerPlugins>
    </configuration>
</project>
