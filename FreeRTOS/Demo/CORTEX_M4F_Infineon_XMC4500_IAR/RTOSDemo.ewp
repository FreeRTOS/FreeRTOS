# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: xmc4500 Infineon xmc4500
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ; system\CMSIS\DeviceSupport\Infineon\XMC45xx; ..\..\Source\include; ..\common\include; ..\..\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: XMC4500_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c main_blinky.c main_full.c RegTest.s
    system/CMSIS/DeviceSupport/Infineon/XMC45xx/startup/iar/: vector_table_M_forXMC4500.s
  group Common_Demo_Source
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c GenQTest.c integer.c PollQ.c recmutex.c semtest.c sp_flop.c
  group FreeRTOS_Source
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/: list.c queue.c tasks.c timers.c
    ../../Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group System
    system/: low_level_init.c
    system/CMSIS/DeviceSupport/Infineon/XMC45xx/: System_XMC4500.c
