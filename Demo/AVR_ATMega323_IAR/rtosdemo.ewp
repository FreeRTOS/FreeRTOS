# IAR project rtosdemo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x55
  General.SCRStackSize: 12
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: IAR_MEGA_AVR
  ICCAVR.CCDiagSuppress: PE815, PE191, TA006, PA082
  ICCAVR.IExtraOptions: --lock_regs 1
  ICCAVR.newCCIncludePaths: ..\..\Source\include; ..\Common\include; $PROJ_DIR$
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm323.xcl
  group (top)
    ../Common/Minimal/: comtest.c flash.c integer.c PollQ.c
    ../../Source/portable/MemMang/: heap_1.c
    ../../Source/: list.c queue.c tasks.c
    ./: main.c
    ParTest/: ParTest.c
    ../../Source/portable/IAR/ATMega323/: port.c portmacro.s90
    serial/: serial.c
