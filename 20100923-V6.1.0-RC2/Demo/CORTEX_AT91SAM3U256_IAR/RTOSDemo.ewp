# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  ICCARM.CCDefines: at91sam3u4; flash
  ICCARM.CCDiagSuppress: pa082
  ICCARM.CCIncludePath2: system; AT91Lib/peripherals; AT91Lib/components; AT91Lib/drivers; AT91Lib; ../../Source/include; ../../Source/portable/IAR/ARM_CM3; .; ../common/include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: .
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: system\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: C:\E\Dev\FreeRTOS\WorkingCopy3\Demo\CORTEX_AT91SAM3U256_IAR\system\flash.icf
  group (top)
    ./: main.c
    ParTest/: ParTest.c
  group AT91Lib
    AT91Lib/drivers/lcd/: draw_hx8347.c font.c lcdd_hx8347.c
    AT91Lib/components/hx8347/: hx8347.c
    AT91Lib/peripherals/lcd/: lcd.c
    AT91Lib/peripherals/irq/: nvic.c
    AT91Lib/peripherals/pio/: pio.c
    AT91Lib/peripherals/pmc/: pmc.c
    AT91Lib/peripherals/usart/: usart.c
  group Common Demo Source
    ../Common/Minimal/: BlockQ.c blocktim.c comtest.c flash.c GenQTest.c integer.c PollQ.c QPeek.c recmutex.c semtest.c
  group FreeRTOS Source
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/: list.c queue.c tasks.c
    serial/: serial.c
  group FreeRTOS Source/port layer
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group System
    system/: board_cstartup_iar.c board_lowlevel.c board_memories.c exceptions.c
