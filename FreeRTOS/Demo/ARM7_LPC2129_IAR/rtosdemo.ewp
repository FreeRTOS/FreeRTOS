# IAR project rtosdemo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2129 Philips LPC2129
  ICCARM.CCDefines: LPC2000_IAR
  ICCARM.CCDiagSuppress: pe815, pe191, pa082, pe167
  ICCARM.CCIncludePath2: ..\..\source\portable\iar\LPC2000; ..\common\include; ..\..\source\include; SrcIAR; $PROJ_DIR$
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: srciar\; ..\..\include\; ..\common\include; ..\..\Source\include; $PROJ_DIR$; ..\..\Source\portable\IAR\LPC2000
  ILINK.IlinkOutputFile: rtosdemo.out
  ILINK.IlinkIcfFile: resource\lpc212x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Bin (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group Demo Source
    ../Common/Minimal/: BlockQ.c comtest.c dynamic.c flash.c integer.c PollQ.c semtest.c
    ../../Source/portable/MemMang/: heap_1.c
    ./: main.c
    ParTest/: ParTest.c
    serial/: serial.c serialISR.s79
  group Scheduler Source
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/LPC2000/: port.c portasm.s79
  group System Files
    SrcIAR/: lpc2xxx_cstartup.s
