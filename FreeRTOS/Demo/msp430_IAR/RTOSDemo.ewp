# IAR project RTOSDemo.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F449 MSP430F449
  General.GStackSize2: 80
  General.GHeapSize2: 8
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: IAR_MSP430
  ICC430.CCDiagSuppress: pa082,pe191
  ICC430.newCCIncludePaths: ..\..\Source\include; ..\Common\include; $PROJ_DIR$
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: $PROJ_DIR$; ..\..\Source\include
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430F449.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group Demo Source
    ../Common/Minimal/: comtest.c flash.c integer.c PollQ.c
    ../../Source/portable/MemMang/: heap_1.c
    ./: main.c
    ParTest/: ParTest.c
    serial/: serial.c serialASM.s43
  group FreeRTOS Source
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/MSP430/: port.c portext.s43
