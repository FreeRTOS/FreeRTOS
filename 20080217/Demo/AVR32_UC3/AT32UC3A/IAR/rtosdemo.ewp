# IAR project rtosdemo.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allaf.h
  General.GSStackSize: 0x800
  General.GCStackSize: 0x800
  General.GHeapSize: 0x8000
  ICCAVR32.CCDefines: BOARD=EVK1100
  ICCAVR32.CCDiagSuppress: Pe191, Pa082
  ICCAVR32.CCIncludePath2: ..\..\UTILS\; ..\..\UTILS\PREPROCESSOR\; ..\..\BOARDS\; ..\..\DRIVERS\INTC\; ..\..\DRIVERS\TC\; ..\..\DRIVERS\PM\; ..\..\DRIVERS\GPIO\; ..\..\DRIVERS\USART\; ..\..\..\..\Source\include\; ..\..\..\Common\include\; ..\..\..\..\Source\portable\IAR\AVR32_UC3\; ..\..\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 0
  ICCAVR32.CCOptStrategy: 2
  AAVR32.AIncludePaths: ..\..\UTILS\; ..\..\UTILS\PREPROCESSOR\; ..\..\DRIVERS\INTC\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ..\..\UTILS\LINKER_SCRIPTS\AT32UC3A\0512\IAR\lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  ICCAVR32.CCOptLevel: 3
  group (top)
    ../../: main.c
    ../../ParTest/: ParTest.c
    ../../serial/: serial.c
  group DLIB
    ../../../../Source/portable/IAR/AVR32_UC3/: read.c write.c
    ../../SERVICES/USB/CLASS/DFU/EXAMPLES/ISP/BOOT/: trampoline.s82
  group Drivers
    ../../DRIVERS/GPIO/: gpio.c
    ../../DRIVERS/INTC/: intc.c
    ../../BOARDS/EVK1100/: led.c
    ../../DRIVERS/PM/: pm.c
    ../../DRIVERS/TC/: tc.c
    ../../DRIVERS/USART/: usart.c
  group FreeRTOS/AVR32_UC3
    ../../../../Source/portable/IAR/AVR32_UC3/: exception.s82 port.c
  group FreeRTOS/Common_demo
    ../../../Common/Minimal/: BlockQ.c comtest.c death.c dynamic.c flash.c flop.c integer.c PollQ.c semtest.c
  group FreeRTOS/Source
    ../../../../Source/portable/MemMang/: heap_3.c
    ../../../../Source/: list.c queue.c tasks.c
