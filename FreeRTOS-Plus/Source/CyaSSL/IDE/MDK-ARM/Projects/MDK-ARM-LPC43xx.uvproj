# Keil uVision project MDK-ARM-LPC43xx.uvproj, settings and files
target MDK-RTX-TCP-FS (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: LCP43xx-MDK-RTX-TCP-FS
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=4
  c define: HAVE_CONFIG_H CYASSL_LPC43xx  __DBG_ITM  CORE_M4  __RTX USE_STDPERIPH_DRIVER  MDK_CONF_RTX_TCP_FS
  c include: ..\MDK-ARM\CyaSSL;../../..;..\LPC43xx\Drivers\include;..\LPC43xx\LPC43xx\Include
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT6: RAM 0x10080000 size 0xa000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group CyaSSL Apps
    ../../../examples/echoclient/: echoclient.c
    ../../../examples/echoserver/: echoserver.c
    ../../../ctaocrypt/test/: test.c
    ../../../ctaocrypt/benchmark/: benchmark.c
    ../../../examples/client/: client.c
    ../../../examples/server/: server.c
    ../MDK-ARM/CyaSSL/: shell.c main.c cert_data.c
  group LPC43xx
    ../LPC43xx/Drivers/source/: lpc43xx_rtc.c lpc43xx_timer.c lpc43xx_cgu.c lpc43xx_scu.c
  group MDK-ARM
    c:/Keil/ARM/RV31/LIB/: FS_CM3.lib TCPD_CM3.lib TCP_CM3.lib
    c:/Keil/ARM/RV31/LIB//: RTX_CM3.lib
    C:/Keil/ARM/Boards/Keil/MCB4300/RL/FlashFS/SD_File/: Serial.c SDIO_LPC43xx.c system_LPC43xx.c
    C:/Keil/ARM/RL/TCPnet/Drivers/: ETH_LPC43xx.c
  group CyaSSL Library
    ../../../src/: crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
    ../MDK-ARM/CyaSSL/: ssl-dummy.c
  group Crypt/Cipher Library
    ../../../ctaocrypt/src/: aes.c arc4.c asm.c asn.c camellia.c coding.c des3.c dh.c dsa.c ecc.c ecc_fp.c error.c hc128.c hmac.c integer.c logging.c md2.c md4.c md5.c memory.c misc.c wc_port.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c tfm.c
  group Configuration
    ../MDK-ARM/config/: File_Config.c Net_Config.c RTX_Conf_CM.c Net_Debug.c
    ../MDK-ARM/CyaSSL/: config.h config-FS.h config-RTX-TCP-FS.h config-BARE-METAL.h
    ../LPC43xx/: startup_LPC43xx.s
  group CyaSSL-MDK
    ../MDK-ARM/CyaSSL/: cyassl_MDK_ARM.c Retarget.c
    ../LPC43xx/: time-LCP43xx.c
target MDK-FS (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: as above
  output: LCP43xx-MDK-FS
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=4
  c define: HAVE_CONFIG_H CYASSL_LPC43xx  __DBG_ITM CORE_M4  __RTX USE_STDPERIPH_DRIVER  MDK_CONF_FS
  c include: as above
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT6: RAM 0x10080000 size 0xa000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
target MDK-BARE-METAL (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: as above
  output: LCP43xx-MDK-BARE-METAL
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=4
  c define: HAVE_CONFIG_H CYASSL_LPC43xx  __DBG_ITM  CORE_M4  __RTX USE_STDPERIPH_DRIVER  MDK_CONF_BARE_METAL
  c include: as above
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT6: RAM 0x10080000 size 0xa000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
