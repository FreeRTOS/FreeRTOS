# IAR project rtosdemo.ewp, settings and files
configuration Debug (78000, debug)
  General.GHeapSize: 512
  General.GFarHeapSize: 4096
  General.GeneralDeviceSelect: 78F1166_A0 78K0R - uPD78F1166_A0
  ICC78000.CCDefines: __IAR_78KOR_Kx3__
  ICC78000.CCDiagSuppress: Pa082
  ICC78000.CCIncludePath2: ..\..\Source\include; ..\Common\include; Int78K0R; $PROJ_DIR$
  ICC78000.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC78000.CCOptLevel: 0
  ICC78000.CCOptStrategy: 0
  A78000.ADefines: __FAR_MODEL__; __NEAR_DATA_MODEL__
  A78000.OAIncludePath2: ..\..\Source\portable\IAR\78K0R; $PROJ_DIR$
  A78000.OAStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk78f1166_a0.xcl
  XLINK.XlinkStackSize: 1
configuration Release (78000)
  as the first configuration, except:
  ICC78000.CCIncludePath2: ..\..\Source\include; ..\Common\include; LEDtoggle; Int78K0R; $PROJ_DIR$
  ICC78000.CCOptLevel: 3
  ICC78000.CCOptStrategy: 1
  A78000.ADefines: __FAR_MODEL__; __FAR_DATA_MODEL__
  A78000.OAIncludePath2: ..\..\Source\include; ..\Common\include; LEDtoggle; $PROJ_DIR$
  group Demo Source
    ./: ButtonISR.s26 ButtonTask.c main.c RegTest.s26
  group Demo Source/StandardDemos
    ../Common/Minimal/: blocktim.c dynamic.c GenQTest.c PollQ.c semtest.c
  group Kernel Source
    ../../Source/portable/MemMang/: heap_1.c
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/78K0R/: port.c portasm.s26
