# IAR project RTOSDemo.ewp, settings and files
configuration XMC4500 (ARM, debug)
  General.OGChipSelectEditMenu: XMC4500-F144x1024 Infineon XMC4500-F144x1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: PART_XMC4500
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ; system\; ..\..\Source\include; ..\common\include; ..\..\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration XMC4200 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: XMC4200-F64x256 Infineon XMC4200-F64x256
  ICCARM.CCDefines: PART_XMC4200
  ILINK.IlinkIcfFile: XMC4200.icf
configuration XMC4400 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: xmc4400 Infineon xmc4400
  ICCARM.CCDefines: PART_XMC4400
  group (top)
    ./: FreeRTOSConfig.h main.c main_blinky.c main_full.c RegTest.s
  group Common_Demo_Source
    ../Common/Minimal/: blocktim.c dynamic.c GenQTest.c QueueOverwrite.c QueueSet.c recmutex.c sp_flop.c
  group FreeRTOS_Source
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/: list.c queue.c tasks.c timers.c
    ../../Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group System
    system/: startup_XMC4200.s startup_XMC4400.s startup_XMC4500.s System_XMC4200.c System_XMC4400.c system_XMC4500.c
