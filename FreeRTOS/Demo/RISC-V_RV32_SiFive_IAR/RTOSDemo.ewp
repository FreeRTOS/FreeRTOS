# IAR project RTOSDemo.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: E31Arty35T SiFive E31 Arty 35T
  General.GHeapSize: 0x1000
  ICCRISCV.IccLang: 0
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 0
  ICCRISCV.CCIncludePath2: $PROJ_DIR$; ..\..\Source\include; ..\..\Source\portable\IAR\RISC-V; ..\..\Source\portable\IAR\RISC-V\chip_specific_extensions\RV32I_CLINT_no_extensions; ..\Common\include
  IASMRISCV.AsmIncludePath: ..\..\Source\portable\IAR\RISC-V\chip_specific_extensions\RV32I_CLINT_no_extensions
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCOptLevel: 3
  ICCRISCV.CCDefines: NDEBUG
  group (top)
    ./: FreeRTOSConfig.h main.c
  group blinky_demo
    main_blinky/: main_blinky.c
  group FreeRTOS_source
    ../../Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_source/include
    ../../Source/include/: event_groups.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
  group FreeRTOS_source/portable
    ../../Source/portable/IAR/RISC-V/: port.c portASM.s
  group FreeRTOS_source/portable/memmang
    ../../Source/portable/MemMang/: heap_4.c
  group full_demo
    full_demo/: main_full.c RegTest.s
  group full_demo/common
    ../Common/Minimal/: AbortDelay.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c GenQTest.c MessageBufferDemo.c recmutex.c StreamBufferDemo.c StreamBufferInterrupt.c TaskNotify.c TimerDemo.c
