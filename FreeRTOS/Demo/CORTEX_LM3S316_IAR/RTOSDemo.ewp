# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S316 Luminary LM3S316
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BUILD_ALL; ewarm; IAR_ARMCM3_LM
  ICCARM.CCDiagSuppress: Pa050, Pa082
  ICCARM.CCIncludePath2: ; hw_include; ..\common\include; ..\..\source\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: BUILD_ALL; ewarm
  AARM.AUserIncludes: 
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: LM3S316.icf
  ILINK.IlinkAdditionalLibs: ..\Common\drivers\LuminaryMicro\IAR\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Demo Source
    ./: commstest.c main.c registertest.s
    ParTest/: ParTest.c
  group FreeRTOS Source
    ../../Source/portable/MemMang/: heap_1.c
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Luminary Code
    hw_include/: cspy.c pdc.c startup.c
