# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8n.h
  General.OGChipSelectEditMenu: LM3S316 Luminary LM3S316
  ICCARM.CCDefines: BUILD_ALL; ewarm; IAR_ARMCM3_LM
  ICCARM.CCDiagSuppress: Pa050, Pa082
  ICCARM.CCIncludePath2: ; hw_include; ..\common\include; ..\..\source\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: BUILD_ALL; ewarm
  AARM.AUserIncludes: 
  XLINK.XclFile: standalone.xcl
  group Demo Source
    ./: commstest.c main.c registertest.s
    ../Common/Minimal/: crflash.c
    ParTest/: ParTest.c
  group FreeRTOS Source
    ../../Source/: croutine.c list.c queue.c tasks.c
    ../../Source/portable/MemMang/: heap_1.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Libraries
    hw_include/: driverlib.r79
  group Luminary Code
    hw_include/: cspy.c pdc.c startup.c
