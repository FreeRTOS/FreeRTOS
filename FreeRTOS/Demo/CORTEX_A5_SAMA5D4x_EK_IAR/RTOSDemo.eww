<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RTOSDemo.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ddram</name>
      <member>
        <project>libchip_sama5d4x</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sama5d4x</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>RTOSDemo</project>
        <configuration>ddram</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sram</name>
      <member>
        <project>libchip_sama5d4x</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sama5d4x</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>RTOSDemo</project>
        <configuration>sram</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>libchip_sama5d4x</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libchip_sama5d4x</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>libboard_sama5d4x</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>libboard_sama5d4x</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>RTOSDemo</project>
        <configuration>sram</configuration>
      </member>
      <member>
        <project>RTOSDemo</project>
        <configuration>ddram</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


