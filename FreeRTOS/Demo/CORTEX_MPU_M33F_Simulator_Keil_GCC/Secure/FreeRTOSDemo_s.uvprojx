# Keil uVision project FreeRTOSDemo_s.uvprojx, settings and files
target FVP Simulation Model (6190000::V6.19::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: FreeRTOSDemo_s
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\Config;..\..\..\Source\include;..\..\..\Source\portable\GCC\ARM_CM33\secure
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\FreeRTOSDemo_s.sct
  group SecureContext
    ../../../Source/portable/GCC/ARM_CM33/secure/: secure_context.h secure_context.c secure_context_port.c secure_port_macros.h
  group SecureInit
    ../../../Source/portable/GCC/ARM_CM33/secure/: secure_init.h secure_init.c
  group SecureHeap
    ../../../Source/portable/GCC/ARM_CM33/secure/: secure_heap.h secure_heap.c
  group NSCFunctions
    ../../Common/ARMv8M/tz_demo/: nsc_functions.h nsc_functions.c
    ../../Common/ARMv8M/reg_tests/GCC/ARM_CM33/secure/: secure_reg_test_asm.c secure_reg_test_asm.h
  group User
    ./: main_s.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.1.0
