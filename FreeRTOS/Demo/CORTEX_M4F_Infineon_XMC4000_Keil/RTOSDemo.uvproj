# Keil uVision project RTOSDemo.uvproj, settings and files
target RTOSDemo - XMC4500 (ARM-ADS)
  device: XMC4500-1024 Infineon
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x0C000000-0x0C0FFFFF) IROM2(0x08000000-0x080FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: RTOSDemo
  c flags: Optim=1
  c define: rvkdm PART_XMC4500
  c misc: --cpu Cortex-M4.fp --no_allow_fpreg_for_nonfpdata
  c include: ..\CORTEX_M4F_Infineon_XMC4000_Keil;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM4F;..\Common\include
  library: MicroLIB
  memory RVCT4: ROM 0xc000000 size 0x100000
  memory RVCT5: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --entry=Reset_Handler
  group Startup
    ./: startup_XMC4500.s System_XMC4500.c startup_XMC4200.s system_XMC4200.c system_XMC4400.c startup_XMC4400.s
  group Demo_Source
    ./: main.c FreeRTOSConfig.h RegTest.c main_full.c main_blinky.c
  group FreeRTOS_Source
    ../../Source/: timers.c list.c queue.c tasks.c
    ../../Source/portable/RVDS/ARM_CM4F/: port.c
    ../../Source/portable/MemMang/: heap_4.c
  group Common_Demo_Source
    ../Common/Minimal/: semtest.c sp_flop.c blocktim.c countsem.c dynamic.c GenQTest.c recmutex.c
target RTOSDemo - XMC4400 (ARM-ADS)
  device: XMC4400-512 Infineon
  cpu: IRAM(0x20000000-0x20007FFF) IRAM2(0x1FFFC000-0x1FFFFFFF) IROM(0x0C000000-0x0C07FFFF) IROM2(0x08000000-0x0807FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: RTOSDemo
  c flags: Optim=1
  c define: rvkdm PART_XMC4400
  c misc: --cpu Cortex-M4.fp --no_allow_fpreg_for_nonfpdata
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0xc000000 size 0x80000
  memory RVCT5: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fffc000 size 0x4000
  link misc: --entry=Reset_Handler
target RTOSDemo - XMC4200 (ARM-ADS)
  device: XMC4200-256 Infineon
  cpu: IRAM(0x20000000-0x20005FFF) IRAM2(0x1FFFE000-0x1FFFFFFF) IROM(0x0C000000-0x0C03FFFF) IROM2(0x08000000-0x0803FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: RTOSDemo
  c define: rvkdm PART_XMC4200
  c misc: --cpu Cortex-M4.fp --no_allow_fpreg_for_nonfpdata
  c include: ..\CORTEX_M4F_Infineon_XMC4500_Keil;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM4F;..\Common\include;.
  library: MicroLIB
  memory RVCT4: ROM 0xc000000 size 0x40000
  memory RVCT5: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  link misc: --entry=Reset_Handler
