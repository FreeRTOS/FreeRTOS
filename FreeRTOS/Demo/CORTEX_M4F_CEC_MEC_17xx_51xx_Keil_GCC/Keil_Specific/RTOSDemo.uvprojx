# Keil uVision project RTOSDemo.uvprojx, settings and files
target RTOSDemo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: RTOSDemo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..;..\..\..\Source\include;..\..\..\Source\portable\RVDS\ARM_CM4F;..\..\Common\include;..\peripheral_library;..\CMSIS;..\main_full;..\peripheral_library\interrupt
  library: MicroLIB
  memory RVCT4: ROM 0xe0000 size 0x38000
  memory RVCT9: RAM 0x118000 size 0x8000
  group System
    ./: startup_MPS_CM4.S
  group main_and_config
    ../: main.c FreeRTOSConfig.h
  group FreeRTOS_Source
    ../../../Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../Source/portable/RVDS/ARM_CM4F/: port.c
  group peripheral_library
    ../peripheral_library/interrupt/: interrupt_api.c interrupt_ecia_perphl.c interrupt_nvic_perphl.c
    ../peripheral_library/basic_timer/: btimer_api.c btimer_perphl.c
    ../peripheral_library/pcr/: pcr_api.c pcr_perphl.c
    ../peripheral_library/: system_internal.c
