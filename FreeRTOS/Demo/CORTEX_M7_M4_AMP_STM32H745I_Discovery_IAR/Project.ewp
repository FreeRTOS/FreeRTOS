# IAR project Project.ewp, settings and files
configuration STM32H745I_Discovery_CM7 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H745XI_CM7 ST STM32H745XI_CM7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H745xx; USE_STM32H745I_DISCO; CORE_CM7
  ICCARM.CCIncludePath2: CM7\include; ST_code\STM32H7xx_HAL_Driver\Inc; ST_code\BSP\STM32H745I-Discovery; ST_code\BSP\Components\Common; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM4F; ST_code\CMSIS\Device\ST\STM32H7xx\Include; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: CM7\include
  OBJCOPY.OOCOutputFile: STM32H745I_Discovery_CM7.hex
  ILINK.IlinkOutputFile: STM32H745I_Discovery_CM7.out
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H745I_Discovery_CM4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H745XI_CM4 ST STM32H745XI_CM4
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H745xx; USE_STM32H745I_DISCO; USE_IOEXPANDER; CORE_CM4
  ICCARM.CCIncludePath2: CM4\include; ST_code\CMSIS\Device\ST\STM32H7xx\Include; ST_code\STM32H7xx_HAL_Driver\Inc; ST_code\BSP\STM32H745I-Discovery; ST_code\BSP\Components\Common; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM4F; $PROJ_DIR$; ST_code\CMSIS\Include
  AARM.AUserIncludes: CM4\include
  OBJCOPY.OOCOutputFile: STM32H745I_Discovery_CM4.hex
  ILINK.IlinkOutputFile: STM32H745I_Discovery_CM4.out
  ILINK.IlinkIcfFile: stm32h7xx_CM4_FLASH.icf
  group Application/EWARM
    ./: startup_stm32h745xx.s
  group Application/User/CM4
    CM4/include/: FreeRTOSConfig.h
    CM4/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Application/User/CM7
    CM7/include/: FreeRTOSConfig.h
    CM7/: main.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
  group FreeRTOS_Source
    ../../Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Source/include
    ../../Source/include/: event_groups.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
  group FreeRTOS_Source/portable/IAR
    ../../Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group FreeRTOS_Source/portable/MemMang
    ../../Source/portable/MemMang/: heap_4.c
  group ST_code/BSP/STM32H745I_Discovery
    ST_code/BSP/STM32H745I-Discovery/: stm32h745i_discovery.c
  group ST_code/CMSIS
    ./: system_stm32h7xx.c
  group ST_code/STM32H7xx_HAL_Driver
    ST_code/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
