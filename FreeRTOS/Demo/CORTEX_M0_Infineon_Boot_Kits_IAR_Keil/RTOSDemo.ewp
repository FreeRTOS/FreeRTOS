# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: xmc1200 Infineon xmc1200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: Dave\Generated\inc\DAVESupport; ..\..\source\include; ..\..\source\portable\IAR\ARM_CM0; .; System_IAR; ..\common\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$.\
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main-blinky.c main-full.c main.c ParTest_XMC1200.c RegTest_IAR.s
  group CMSIS
    System_IAR/: startup_XMC1200.s system_XMC1200.c
  group Common Demo Source
    ../Common/Minimal/: blocktim.c countsem.c dynamic.c recmutex.c
  group Dave/Generated/src/BCCUCH01
    Dave/Generated/src/BCCUCH01/: BCCUCH01.c BCCUCH01_Conf.c
  group Dave/Generated/src/BCCUDIM01
    Dave/Generated/src/BCCUDIM01/: BCCUDIM01.c BCCUDIM01_Conf.c
  group Dave/Generated/src/BCCUGLOBAL
    Dave/Generated/src/BCCUGLOBAL/: BCCUGLOBAL.c BCCUGLOBAL_Conf.c
  group Dave/Generated/src/CLK002
    Dave/Generated/src/CLK002/: CLK002.c
  group Dave/Generated/src/COLORLAMP01
    Dave/Generated/src/COLORLAMP01/: COLORLAMP01.c COLORLAMP01_Conf.c
  group Dave/Generated/src/DAVESupport
    Dave/Generated/src/DAVESupport/: DAVE3.c MULTIPLEXER.c
  group Dave/Generated/src/IO003
    Dave/Generated/src/IO003/: IO003.c IO003_Conf.c
  group FreeRTOS Source
    ../../Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS Source/portable
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/IAR/ARM_CM0/: port.c portasm.s
