# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F756NG ST STM32F756NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F756xx; CORE_CM7; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ST_Library\include; CMSIS\Include; CMSIS\Device\ST\STM32F7xx\Include; System_IAR; ..\Common\include; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM7\r0p1; Full_Demo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTOSDemo.bin
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: System_IAR\stm32f756xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group Blinky_Demo
    Blinky_Demo/: main_blinky.c
  group FreeRTOS_Source
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/Portable
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s portmacro.h
  group Full_Demo
    Full_Demo/: IntQueueTimer.c main_full.c RegTest_IAR.s
  group Full_Demo/Common_Demo_Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flash.c flop.c GenQTest.c integer.c IntQueue.c IntSemTest.c PollQ.c QPeek.c QueueOverwrite.c QueueSet.c recmutex.c semtest.c TaskNotify.c TimerDemo.c
  group ST_Library
    ST_Library/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
  group System
    System_IAR/: startup_stm32f756xx.s stm32f7xx_hal_msp.c stm32f7xx_it.c system_stm32f7xx.c
