# IAR project RTOSDemo.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCIncludePath2: .; ..\Common\include; ..\..\Source\include; ..\..\Source\portable\IAR\RX600; include
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Blinky (RX, debug)
  as the first configuration, except:
  General.GenDataModel: 2
  General.IStackSize: 0x200
  General.HeapSize: 0x4
  group (top)
    ./: HighFrequencyTimerTest.c IntQueueTimer.c main-blinky.c main-full.c ParTest.c RegTest.s
  group Common Demo Files
    ../Common/Minimal/: BlockQ.c blocktim.c death.c flash.c flop.c GenQTest.c integer.c IntQueue.c PollQ.c QPeek.c recmutex.c semtest.c
  group FreeRTOS Source
    ../../Source/: list.c queue.c tasks.c
  group FreeRTOS Source/Portable Layer
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/IAR/RX600/: port.c port_asm.s
