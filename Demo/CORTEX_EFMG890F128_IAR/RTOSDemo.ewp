# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G890F128 EnergyMicro EFM32G890F128
  ICCARM.CCDefines: EFM32G890F128; IAR_ARM_CM3
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ; ..\common\include; ..\..\Source\include; lcd; CMSIS\CM3\CoreSupport; CMSIS\CM3\DeviceSupport\EnergyMicro\EFM32; bsp
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32G290F128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: startup_efm32.s
  group Demo
    ./: lcdtest.c ledtest.c main.c ParTest.c
  group Demo/Common demo tasks
    ../Common/Minimal/: GenQTest.c QPeek.c recmutex.c semtest.c
  group Energy Micro Code
    lcd/: lcdcontroller.c
  group Energy Micro Code/bsp
    bsp/: dvk.c dvk_boardcontrol.c dvk_ebi.c dvk_spi.c
  group Energy Micro Code/CMSIS
    CMSIS/CM3/CoreSupport/: core_cm3.c
    CMSIS/CM3/DeviceSupport/EnergyMicro/EFM32/: system_efm32.c
  group FreeRTOS source
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/: list.c queue.c tasks.c
  group FreeRTOS source/Port layer
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
