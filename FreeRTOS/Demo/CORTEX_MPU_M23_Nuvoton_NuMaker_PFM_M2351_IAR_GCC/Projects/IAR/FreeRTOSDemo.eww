<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
    <project>
        <path>$WS_DIR$\Secure\FreeRTOSDemo_s.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Nonsecure\FreeRTOSDemo_ns.ewp</path>
    </project>


  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>FreeRTOSDemo_s</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>FreeRTOSDemo_ns</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


