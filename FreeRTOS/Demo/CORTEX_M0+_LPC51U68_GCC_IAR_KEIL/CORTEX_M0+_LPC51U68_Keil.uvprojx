# Keil uVision project CORTEX_M0+_LPC51U68_Keil.uvprojx, settings and files
target CORTEX_M0+_LPC51U68_Keil (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC51U68JBD64 NXP
  pack: NXP.LPC51U68_DFP.12.0.0
  cpu: IRAM(0x20000000,0x010000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CORTEX_M0+_LPC51U68_Keil
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x0)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM0;..\Common\include;.\CMSIS;.\app;.\board\boards;.\component\lists;.\component\serial_manager;.\component\uart;.\device;.\drivers;.\utilities;.\Keil_specific
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x4000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Keil_specific\LPC51U68_flash.scf
  group Application_Code
    ./app/: main_full.c main_blinky.c main.c IntQueueTimer.h IntQueueTimer.c FreeRTOSConfig.h
    ./Keil_specific/: RegTest_Keil.s compiler_attributes.h
  group board
    ./board/boards/: board.c board.h clock_config.c clock_config.h peripherals.c peripherals.h pin_mux.c pin_mux.h
  group component-lists
    ./component/lists/: generic_list.h generic_list.c
  group component-serial-manager
    ./component/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group componnet-uart
    ./component/uart/: uart.h usart_adapter.c
  group device
    ./device/: fsl_device_registers.h LPC51U68.h LPC51U68_features.h system_LPC51U68.c system_LPC51U68.h
  group drivers
    ./drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_ctimer.c fsl_ctimer.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_iocon.h fsl_pint.c fsl_pint.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group startup
    ./Keil_specific/: startup_LPC51U68.s
  group utilities
    ./utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
  group CMSIS
    ./CMSIS/: arm_common_tables.h arm_const_structs.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h
  group FreeRTOS_Source
    ../../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
    ../../Source/portable/RVDS/ARM_CM0/: port.c portmacro.h
    ../../Source/portable/MemMang/: heap_5.c
  group Stadard_Demo_Tasks
    ../Common/include/: blocktim.h countsem.h IntQueue.h recmutex.h
    ../Common/Minimal/: blocktim.c IntQueue.c recmutex.c countsem.c
  group libs
    ./Keil_specific/: keil_lib_power.lib
