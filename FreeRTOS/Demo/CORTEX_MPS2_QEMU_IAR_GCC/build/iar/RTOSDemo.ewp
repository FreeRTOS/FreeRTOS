# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: pe550, pe144, pa039
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\common\include; ..\..\..\..\Source\include; ..\..\CMSIS; ..\..\..\..\Source\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: MPS2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: FreeRTOSConfig.h main.c
  group Blinky Demo
    ../../: main_blinky.c
  group FreeRTOS Kernel
    ../../../../Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS Kernel/include
    ../../../../Source/include/: event_groups.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
  group FreeRTOS Kernel/Portable/IAR/ARM_CM3
    ../../../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group FreeRTOS Kernel/Portable/MemMang
    ../../../../Source/portable/MemMang/: heap_4.c
  group Full Demo
    ../../: main_full.c
  group Full Demo/Standard Demo Tasks
    ../../../Common/Minimal/: AbortDelay.c BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c GenQTest.c integer.c IntQueue.c IntSemTest.c MessageBufferAMP.c MessageBufferDemo.c PollQ.c QPeek.c QueueOverwrite.c QueueSet.c QueueSetPolling.c recmutex.c semtest.c StaticAllocation.c StreamBufferDemo.c StreamBufferInterrupt.c TaskNotify.c TaskNotifyArray.c TimerDemo.c
    ../../: IntQueueTimer.c
  group System files
    ./: startup_ewarm.c
