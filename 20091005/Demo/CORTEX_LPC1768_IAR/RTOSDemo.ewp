# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCDefines: PACK_STRUCT_END=
  ICCARM.CCDiagSuppress: Pe550, Pa082, Pa039
  ICCARM.CCIncludePath2: ..\common\include; ..\..\source\include; ..\..\source\portable\iar\arm_cm3; $PROJ_DIR$; ..\Common\ethernet\uIP\uip-1.0\uip; lpcusb; webserver
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: LPC1768_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: cstartup_M.s main.c ParTest.c
  group Common Demo Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c flash.c GenQTest.c integer.c PollQ.c QPeek.c recmutex.c semtest.c
  group FreeRTOS
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group LPCUSB
    LPCUSB/: USB_CDC.c usbcontrol.c usbhw_lpc.c usbinit.c usbstdreq.c
  group WEB Server
    webserver/: emac.c http-strings.c httpd-cgi.c httpd-fs.c httpd.c uIP_Task.c
    ../Common/ethernet/uIP/uip-1.0/uip/: psock.c timer.c uip.c uip_arp.c
