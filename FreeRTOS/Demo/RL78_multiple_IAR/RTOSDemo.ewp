# IAR project RTOSDemo.ewp, settings and files
configuration YRPBRL78G13 (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: YRPBRL78G13
  ICCRL78.CCDiagSuppress: Pa082
  ICCRL78.CCIncludePath2: ..\..\Source\include; ..\Common\include; $PROJ_DIR$; ..\..\Source\portable\IAR\RL78
  ICCRL78.IccExtraOptions: --silent
  ARL78.AsmIncludePath: ..\..\Source\portable\IAR\RL78; $PROJ_DIR$
  ARL78.AsmExtraOptions: --silent
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration YRPBRL78G14 (RL78, debug)
  as the first configuration, except:
  General.GenDeviceSelect: R5F104LE RL78 - R5F104LE
  ICCRL78.CCDefines: YRPBRL78G14
  ICCRL78.CCIncludePath2: ..\..\Source\include; ..\Common\include; ..\..\Source\portable\IAR\RL78; $PROJ_DIR$
configuration YRDKRL78G14 (RL78, debug)
  as the first configuration, except:
  General.GenDeviceSelect: R5F104PJ RL78 - R5F104PJ
  General.GenCodeModel: 1
  General.GenDataModel: 1
  ICCRL78.CCDefines: YRDKRL78G14
  ICCRL78.CCIncludePath2: as above
configuration RSKRL78G1C (RL78, debug)
  as the first configuration, except:
  General.GenDeviceSelect: R5F10JGC RL78 - R5F10JGC
  ICCRL78.CCDefines: RSKRL78G1C
  ICCRL78.CCDiagSuppress: Pa082, Pe1053
configuration RSKRL78L13 (RL78, debug)
  as the first configuration, except:
  General.GenDeviceSelect: R5F10WMG RL78 - R5F10WMG
  General.GenCodeModel: 1
  General.GenDataModel: 1
  ICCRL78.CCDefines: RSKRL78L13
  ICCRL78.CCDiagSuppress: Pa082, Pe1053
configuration RSKRL78L1C (RL78, debug)
  as the first configuration, except:
  General.GenDeviceSelect: R5F110PJ RL78 - R5F110PJ
  General.GenCodeModel: 1
  General.GenDataModel: 1
  ICCRL78.CCDefines: RSKRL78L1C
  ICCRL78.CCDiagSuppress: Pa082, Pe1053
configuration QB_R5F10ELE_TB (RL78, debug)
  as the first configuration, except:
  General.GenDeviceSelect: R5F10ELE RL78 - R5F10ELE
  ICCRL78.CCDefines: QB_R5F10ELE_TB
  ICCRL78.CCDiagSuppress: Pa082, Pe1053
  group Demo Source
    ./: demo_specific_io.h interrupt_vector.s main.c main_blinky.c main_full.c RegTest.s
  group Demo Source/StandardDemos
    ../Common/Minimal/: blocktim.c dynamic.c PollQ.c
  group Kernel Source
    ../../Source/portable/MemMang/: heap_1.c
    ../../Source/: list.c queue.c tasks.c timers.c
    ../../Source/portable/IAR/RL78/: port.c portasm.s
