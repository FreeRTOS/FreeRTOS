# IAR project rtosdemo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM7S64 Atmel AT91SAM7S64
  ICCARM.CCDefines: SAM7_IAR
  ICCARM.CCDiagSuppress: pe815, pe191, pa082, pe167
  ICCARM.CCIncludePath2: ..\..\source\portable\iar\AtmelSAM7S64; ..\common\include; ..\..\source\include; SrcIAR; $PROJ_DIR$
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  AARM.AUserIncludes: srciar\; ..\..\include\; ..\common\include; ..\..\Source\include; ..\..\Source\portable\IAR\AtmelSAM7S64
  ILINK.IlinkOutputFile: rtosdemo.out
  ILINK.IlinkIcfFile: resource\at91SAM7S64_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Bin (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: srciar\; ..\common\include; ..\..\Source\include; ..\..\Source\portable\IAR\AtmelSAM7S64
  group Demo Source
    ../Common/Minimal/: BlockQ.c comtest.c dynamic.c flash.c integer.c PollQ.c semtest.c
    ../../Source/portable/MemMang/: heap_1.c
    ./: main.c
    ParTest/: ParTest.c
    serial/: serial.c serialISR.s79
    USB/: USB_ISR.s79 USBSample.c
  group Scheduler Source
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/AtmelSAM7S64/: port.c portasm.s79
  group System Files
    SrcIAR/: Cstartup.s Cstartup_SAM7.c
