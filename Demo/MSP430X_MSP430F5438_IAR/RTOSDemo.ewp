# IAR project RTOSDemo.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlff.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa082
  ICC430.newCCIncludePaths: F5XX_6XX_Core_Lib; MSP-EXP430F5438_HAL; UserExperienceDemo; ..\Common\include; ..\..\Source\include; ..\..\Source\portable\IAR\MSP430X; $PROJ_DIR$
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: $PROJ_DIR$
  XLINK.XclFile: lnk430F5438A_mod.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430, debug)
  as the first configuration, except:
  ICC430.CCOptLevel: 3
  group (top)
    ./: lnk430F5438A_mod.xcl low_level_init.c main.c ParTest.c readme.txt RegTest.s43 RunTimeStatsConfig.c serial.c
  group F5XX_6XX_Core_Lib
    F5XX_6XX_Core_Lib/: hal_UCS.c
  group FreeRTOS_Source
    ../../Source/: list.c queue.c tasks.c
  group FreeRTOS_Source/Portable
    ../../Source/portable/MemMang/: heap_1.c
    ../../Source/portable/IAR/MSP430X/: port.c portext.s43
  group MSP-EXP430F5438_HAL
    MSP-EXP430F5438_HAL/: hal_board.c hal_buttons.c hal_lcd.c hal_lcd_fonts.c hal_MSP-EXP430F5438.h
  group Standard_Demo_Tasks
    ../Common/Minimal/: comtest.c dynamic.c GenQTest.c
