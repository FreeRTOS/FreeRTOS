# Keil uVision project MPUDemo.uvprojx, settings and files
target MPUDemo (6130001::V6.13.1::.\ARMCLANG)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: MPUDemo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L475xx
  c include: ../../ST_Code/Core/Inc;../../ST_Code/Drivers/STM32L4xx_HAL_Driver/Inc;../../ST_Code/Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../ST_Code/Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../ST_Code/Drivers/CMSIS/Include;../../Config;../../Demo;../../../../Source/include;../../../../Source/portable/GCC/ARM_CM4_MPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: MPUDemo.sct
  group Startup
    ./: startup_stm32l475xx.s
    ./: memfault_handler.c
  group FreeRTOS
    ../../../../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Source/portable/Common/: mpu_wrappers.c mpu_wrappers_v2.c
    ../../../../Source/portable/GCC/ARM_CM4_MPU/: port.c mpu_wrappers_v2_asm.c portmacro.h
    ../../../../Source/portable/MemMang/: heap_4.c
  group Config
    ../../Config/: FreeRTOSConfig.h
  group Demo
    ../../Demo/: app_main.c app_main.h mpu_demo.c mpu_demo.h
  group Core
    ../../ST_Code/Core/Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../ST_Code/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_dfsdm.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
  group Drivers/CMSIS
    ../../ST_Code/Core/Src/: system_stm32l4xx.c
software components: CMSIS:CORE 5.3.0
