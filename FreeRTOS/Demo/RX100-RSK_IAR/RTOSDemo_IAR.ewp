# IAR project RTOSDemo_IAR.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F51115 R5F51115
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x4
  General.IStackSize: 0x200
  General.HeapSize: 0x4
  ICCRX.CCDiagSuppress: Pa082
  ICCRX.CCIncludePath2: .; ..\Common\include; ..\..\Source\include; ..\..\Source\portable\IAR\RX100; Renesas_Files/r_bsp/mcu/rx111; Renesas_Files/r_bsp; Renesas_Files/r_bsp/board/rskrx111; Renesas_Files/r_switches; Renesas_Files/r_switches/src}"
  ICCRX.IccExtraOptions: --no_clustering
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\; .
  OBJCOPY.OOCOutputFile: RTOSDemo_IAR.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: FreeRTOSConfig.h main.c main_full.c main_low_power.c ParTest.c reg_test.s
  group FreeRTOS Source
    ../../Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS Source/include
    ../../Source/include/: FreeRTOS.h projdefs.h queue.h semphr.h task.h timers.h
  group FreeRTOS Source/portable/IAR/RX100
    ../../Source/portable/IAR/RX100/: port.c port_asm.s portmacro.h
  group FreeRTOS Source/portable/MemMang
    ../../Source/portable/MemMang/: heap_4.c
  group Renesas Files
    Renesas_Files/r_bsp/board/user/: hardware_setup.c
    Renesas_Files/r_bsp/board/rskrx111/: lcd.c
    Renesas_Files/r_switches/src/: r_switches.c
  group Standard Demo Tasks
    ../Common/Minimal/: blocktim.c death.c GenQTest.c recmutex.c
