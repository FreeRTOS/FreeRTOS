# IAR project RTOSDemo.ewp, settings and files
configuration Debug_Large_Data_Model (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xllfn.h
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  General.GStackSize2: 100
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa082
  ICC430.newCCIncludePaths: ; driverlib\MSP430FR5xx_6xx; ..\..\Source\include; ..\..\Source\portable\IAR\MSP430X; ..\Common\include; ..\..\..\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: __DATA_MODEL_LARGE__
  A430.AUserIncludes: ..\..\Source\portable\IAR\MSP430X; $PROJ_DIR$
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr5969.xcl
  XLINK.XlinkStackSize: 1
configuration Debug_Small_Data_Model (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  ICC430.CCOptLevel: 0
  A430.ADefines: __DATA_MODEL_SMALL__
  group (top)
    ./: FreeRTOSConfig.h LEDs.c main.c main.h
    IAR_Only/: low_level_init_iar.c
  group Blinky_Demo
    Blinky_Demo/: main_blinky.c
  group driverlib/MSP430FR5xx_6xx
    driverlib/MSP430FR5xx_6xx/: adc12_b.c adc12_b.h aes256.c aes256.h comp_e.c comp_e.h crc.c crc.h crc32.c crc32.h cs.c cs.h dma.c dma.h driverlib.h esi.c esi.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h gpio.c gpio.h lcd_c.c lcd_c.h mpu.c mpu.h mpy32.c mpy32.h pmm.c pmm.h ram.c ram.h ref_a.c ref_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sfr.c sfr.h sysctl.c sysctl.h timer_a.c timer_a.h timer_b.c timer_b.h tlv.c tlv.h wdt_a.c wdt_a.h
  group driverlib/MSP430FR5xx_6xx/deprecated/CCS
    driverlib/MSP430FR5xx_6xx/deprecated/CCS/: msp430fr5xx_6xxgeneric.h
  group driverlib/MSP430FR5xx_6xx/deprecated/IAR
    driverlib/MSP430FR5xx_6xx/deprecated/IAR/: msp430fr5xx_6xxgeneric.h
  group driverlib/MSP430FR5xx_6xx/inc
    driverlib/MSP430FR5xx_6xx/inc/: hw_memmap.h hw_regaccess.h hw_types.h version.h
  group FreeRTOS_Source
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/portable
    ../../Source/portable/IAR/MSP430X/: data_model.h port.c portext.s43 portmacro.h
    ../../Source/portable/MemMang/: heap_4.c
  group Full_Demo
    Full_Demo/: main_full.c
    IAR_Only/: RegTest.s43
    ../../../FreeRTOS-Plus/Demo/Common/FreeRTOS_Plus_CLI_Demos/: Sample-CLI-commands.c UARTCommandConsole.c
  group Full_Demo/FreeRTOS+CLI
    ../../../FreeRTOS-Plus/Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
  group Full_Demo/Standard Demo Tasks
    ../Common/Minimal/: blocktim.c countsem.c dynamic.c EventGroupsDemo.c GenQTest.c recmutex.c TaskNotify.c
    Full_Demo/: serial.c
