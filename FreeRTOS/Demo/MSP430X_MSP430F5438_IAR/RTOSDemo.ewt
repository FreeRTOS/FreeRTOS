<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug_Large_Data_Model</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release_Large_Data_Model</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Debug_Small_Data_Model</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Debug_Medium_Data_Model</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <group>
    <name>F5XX_6XX_Core_Lib</name>
    <file>
      <name>$PROJ_DIR$\F5XX_6XX_Core_Lib\HAL_PMM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\F5XX_6XX_Core_Lib\hal_UCS.c</name>
    </file>
  </group>
  <group>
    <name>FreeRTOS_Source</name>
    <group>
      <name>Portable</name>
      <file>
        <name>$PROJ_DIR$\..\..\Source\portable\MemMang\heap_1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Source\portable\IAR\MSP430X\port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Source\portable\IAR\MSP430X\portext.s43</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\Source\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\tasks.c</name>
    </file>
  </group>
  <group>
    <name>MSP-EXP430F5438_HAL</name>
    <file>
      <name>$PROJ_DIR$\MSP-EXP430F5438_HAL\hal_board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MSP-EXP430F5438_HAL\hal_buttons.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MSP-EXP430F5438_HAL\hal_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MSP-EXP430F5438_HAL\hal_lcd_fonts.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MSP-EXP430F5438_HAL\hal_MSP-EXP430F5438.h</name>
    </file>
  </group>
  <group>
    <name>Standard_Demo_Tasks</name>
    <file>
      <name>$PROJ_DIR$\..\Common\Minimal\comtest.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Common\Minimal\dynamic.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Common\Minimal\GenQTest.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\lnk430F5438A_mod.xcl</name>
  </file>
  <file>
    <name>$PROJ_DIR$\low_level_init.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\ParTest.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\RegTest.s43</name>
  </file>
  <file>
    <name>$PROJ_DIR$\RunTimeStatsConfig.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\serial.c</name>
  </file>
</project>


