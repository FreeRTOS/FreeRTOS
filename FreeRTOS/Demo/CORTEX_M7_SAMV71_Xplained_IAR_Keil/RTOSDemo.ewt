<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Atmel_LibBoard</name>
    <file>
      <name>$PROJ_DIR$\libboard_samv7-ek\source\board_lowlevel.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libboard_samv7-ek\source\board_memories.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libboard_samv7-ek\source\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libboard_samv7-ek\resources\IAR\startup_sam.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libboard_samv7-ek\resources\system_sam.c</name>
    </file>
  </group>
  <group>
    <name>Atmel_LibChip</name>
    <file>
      <name>$PROJ_DIR$\libchip_samv7\source\pio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libchip_samv7\source\pmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libchip_samv7\source\supc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libchip_samv7\source\tc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\libchip_samv7\source\wdt.c</name>
    </file>
  </group>
  <group>
    <name>Blinky_Demo</name>
    <file>
      <name>$PROJ_DIR$\Blinky_Demo\main_blinky.c</name>
    </file>
  </group>
  <group>
    <name>FreeRTOS_Source</name>
    <group>
      <name>portable</name>
      <file>
        <name>$PROJ_DIR$\..\..\Source\portable\MemMang\heap_4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Source\portable\IAR\ARM_CM7\r0p1\port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Source\portable\IAR\ARM_CM7\r0p1\portasm.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Source\portable\IAR\ARM_CM7\r0p1\portmacro.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\Source\event_groups.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Source\timers.c</name>
    </file>
  </group>
  <group>
    <name>Full_Demo</name>
    <group>
      <name>Common_Demo_Tasks</name>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\BlockQ.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\blocktim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\countsem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\death.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\dynamic.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\EventGroupsDemo.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\flop.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\GenQTest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\IntQueue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\IntSemTest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\QueueOverwrite.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\QueueSet.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\recmutex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\semtest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\TaskNotify.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Common\Minimal\TimerDemo.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\Full_Demo\IntQueueTimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Full_Demo\IntQueueTimer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Full_Demo\main_full.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Full_Demo\RegTest.s</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
</project>


