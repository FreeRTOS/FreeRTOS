# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR712 ST STR712
  ICCARM.CCDefines: STR71X_IAR
  ICCARM.CCDiagSuppress: pe191, pa082
  ICCARM.CCIncludePath2: ; library\include\; ..\common\include; ..\..\source\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: ..\..\Source\portable\IAR\STR71x
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: STR71x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _NDEBUG; STR71X_IAR
  ICCARM.CCOptLevel: 3
  group Demo Source
    ../Common/Minimal/: BlockQ.c comtest.c dynamic.c flash.c integer.c PollQ.c semtest.c
    ../../Source/portable/MemMang/: heap_2.c
    ./: main.c
    ParTest/: ParTest.c
    serial/: serial.c serialISR.s79
  group Library Source
    Library/: 71x_lib.c gpio.c rccu.c uart.c wdg.c
  group RTOS Source
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/STR71x/: port.c portasm.s79
  group System Files
    ./: 71x_init.s 71x_vect.s
    Library/: 71x_it.c
