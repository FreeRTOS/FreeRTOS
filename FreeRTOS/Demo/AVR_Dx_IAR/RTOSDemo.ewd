<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>3</fileVersion>
    <configuration>
        <name>Debug</name>
        <toolchain>
            <name>AVR</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>6</archiveVersion>
            <data>
                <version>16</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>CSVariantProcessor</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>DDFile</name>
                    <state>$TOOLKIT_DIR$\Config\ioavr128da48.ddf</state>
                </option>
                <option>
                    <name>CInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCEnhancedCore</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OC64BitDoubles</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DdfFileSlave</name>
                    <state></state>
                </option>
                <option>
                    <name>RunToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>RunToName</name>
                    <state>main</state>
                </option>
                <option>
                    <name>newDDFileOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CSVariantEepromSize</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CSVariant64KFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CdDllSlave</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CDynDriver</name>
                    <state>ATMELICEAVR</state>
                </option>
                <option>
                    <name>DebuggerUseUbrofResetVector</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesUse1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse3</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>ATMELICEAVR</name>
            <archiveVersion>7</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>OATMELICEDriver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OATMELICEExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>OATMELICEExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICELogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceSuppLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceConsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceJtagFreqRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceJtagFreqManually</name>
                    <state>100</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceJtagFreq</name>
                    <version>0</version>
                    <state>8</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceJtagDeviceBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceJtagDeviceAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceJtagInstrBitsBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceJtagInstrBitsAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceDaisyChain</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagDebugTimers</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OATMELICEJtagDebugEeprom</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagDebugFuses</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIcedownloadToData</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagSoftwareBreak</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ExitBreakpointP7</name>
                    <state>0</state>
                </option>
                <option>
                    <name>PutcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GetcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OATMELICECommunication</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICECommunicationUsbEditId</name>
                    <state></state>
                </option>
                <option>
                    <name>OATMELICEDebugPort</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OATMELICEDebugWireDebugPort</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OATMELICEAVRJtagIcePreserveFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICETPIDebugPort</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OATMELICEUPDIDebugPort</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>AVRONE</name>
            <archiveVersion>4</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>OAVRONEDriver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OAVRONEExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>OAVRONEExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONELogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceSuppLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceConsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceJtagFreqRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceJtagFreqManually</name>
                    <state>100</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceJtagFreq</name>
                    <version>0</version>
                    <state>8</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceJtagDeviceBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceJtagDeviceAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceJtagInstrBitsBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceJtagInstrBitsAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceDaisyChain</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagDebugTimers</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OAVRONEJtagDebugEeprom</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagDebugReset</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagDebugFuses</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIcedownloadToData</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagSoftwareBreak</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ExitBreakpointP7</name>
                    <state>0</state>
                </option>
                <option>
                    <name>PutcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GetcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OAVRONECommunication</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONECommunicationUsbEditId</name>
                    <state></state>
                </option>
                <option>
                    <name>OAVRONEDebugPort</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEDebugWireDebugPort</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OAVRONEAVRJtagIcePreserveFlash</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>JTAGICE3AVR</name>
            <archiveVersion>6</archiveVersion>
            <data>
                <version>7</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>OJTAGICE3Driver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICE3ExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>OJTAGICE3ExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceSuppLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceConsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceJtagFreqRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceJtagFreqManually</name>
                    <state>100</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceJtagFreq</name>
                    <version>0</version>
                    <state>8</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceJtagDeviceBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceJtagDeviceAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceJtagInstrBitsBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceJtagInstrBitsAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceDaisyChain</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagDebugTimers</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagDebugEeprom</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagDebugFuses</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIcedownloadToData</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagSoftwareBreak</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ExitBreakpointP7</name>
                    <state>0</state>
                </option>
                <option>
                    <name>PutcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GetcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICE3Communication</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3CommunicationUsbEditId</name>
                    <state></state>
                </option>
                <option>
                    <name>OJTAGICE3DebugPort</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3DebugWireDebugPort</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICE3AVRJtagIcePreserveFlash</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>JTAGICEMKIIAVR</name>
            <archiveVersion>5</archiveVersion>
            <data>
                <version>7</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>OJTAGICEMKIIAVRDriver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRPort</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRBaud</name>
                    <version>0</version>
                    <state>5</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRParity</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRDataBits</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRStopBits</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRHandshake</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRAllComm</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceDefaultCom</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceComPort</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceSuppLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceConsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceJtagFreqRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceJtagFreqManually</name>
                    <state>100000</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceJtagFreq</name>
                    <version>0</version>
                    <state>8</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceJtagDeviceBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceJtagDeviceAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceJtagInstrBitsBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceJtagInstrBitsAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceDaisyChain</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagDebugTimers</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagDebugEeprom</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagDebugReset</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagDebugFuses</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIcedownloadToData</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagSoftwareBreak</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ExitBreakpointP7</name>
                    <state>0</state>
                </option>
                <option>
                    <name>PutcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GetcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRCommunicationNew</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRCommunicationUsbEditId</name>
                    <state></state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRUsePDI</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIOnlyPDI</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIcePreserveFlash</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>DRAGONAVR</name>
            <archiveVersion>3</archiveVersion>
            <data>
                <version>3</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>ODRAGONAVRDriver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>ODRAGONAVRExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>ODRAGONAVRExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceSuppLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceConsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceJtagFreqRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceJtagFreqManually</name>
                    <state>100000</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceJtagFreq</name>
                    <version>0</version>
                    <state>8</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceJtagDeviceBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceJtagDeviceAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceJtagInstrBitsBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceJtagInstrBitsAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceDaisyChain</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagDebugTimers</name>
                    <state>1</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagDebugEeprom</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagDebugReset</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagDebugFuses</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIcedownloadToData</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagSoftwareBreak</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ExitBreakpointP7</name>
                    <state>0</state>
                </option>
                <option>
                    <name>PutcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GetcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>ODRAGONAVRCommunicationNew</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRCommunicationUsbEditId</name>
                    <state></state>
                </option>
                <option>
                    <name>ODRAGONAVRUsePDI</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONOnlyPDI</name>
                    <state>1</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIcePreserveFlash</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>POWERDEBUGGERAVR</name>
            <archiveVersion>7</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>OPOWERDEBUGGERDriver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceSuppLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceConsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceJtagFreqRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceJtagFreqManually</name>
                    <state>100</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceJtagFreq</name>
                    <version>0</version>
                    <state>8</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceJtagDeviceBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceJtagDeviceAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceJtagInstrBitsBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceJtagInstrBitsAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceDaisyChain</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagDebugTimers</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagDebugEeprom</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagDebugFuses</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIcedownloadToData</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagSoftwareBreak</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ExitBreakpointP7</name>
                    <state>0</state>
                </option>
                <option>
                    <name>PutcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GetcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERCommunication</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERCommunicationUsbEditId</name>
                    <state></state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERDebugPort</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERDebugWireDebugPort</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERAVRJtagIcePreserveFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERTPIDebugPort</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERUPDIDebugPort</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>SIMAVR</name>
            <archiveVersion>2</archiveVersion>
            <data>
                <version>1</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>OSIMAVRDriver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OSIMAVRExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>OSIMAVRExtraOptionsCheck</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>THIRDPARTYAVR</name>
            <archiveVersion>2</archiveVersion>
            <data>
                <version>1</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>OTHIRDPARTYAVRDriver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OTHIRDPARTYAVRExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>OTHIRDPARTYAVRExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OTHIRDPARTYAVRDriverDll</name>
                    <state>Browse to your Third party driver</state>
                </option>
                <option>
                    <name>OTHIRDPARTYAVRSuppress</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OTHIRDPARTYAVRVerify</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OTHIRDPARTYAVRLogFileCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OTHIRDPARTYAVRLogFileEditB</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
            </data>
        </settings>
        <debuggerPlugins>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-III\uCOS-III-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\Stk600\Stk600Plugin.ewplugin</file>
                <loadFlag>1</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\TargetAccessServer\TargetAccessServer.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\uCProbe\uCProbePlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
        </debuggerPlugins>
    </configuration>
    <configuration>
        <name>Release</name>
        <toolchain>
            <name>AVR</name>
        </toolchain>
        <debug>0</debug>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>6</archiveVersion>
            <data>
                <version>16</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>CSVariantProcessor</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>DDFile</name>
                    <state></state>
                </option>
                <option>
                    <name>CInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCEnhancedCore</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OC64BitDoubles</name>
                    <state>1</state>
                </option>
                <option>
                    <name>DdfFileSlave</name>
                    <state></state>
                </option>
                <option>
                    <name>RunToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>RunToName</name>
                    <state>main</state>
                </option>
                <option>
                    <name>newDDFileOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CSVariantEepromSize</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CSVariant64KFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CdDllSlave</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CDynDriver</name>
                    <state>SIMAVR</state>
                </option>
                <option>
                    <name>DebuggerUseUbrofResetVector</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesUse1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse3</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>ATMELICEAVR</name>
            <archiveVersion>7</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>OATMELICEDriver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OATMELICEExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>OATMELICEExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICELogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceSuppLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceConsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceJtagFreqRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceJtagFreqManually</name>
                    <state>100</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceJtagFreq</name>
                    <version>0</version>
                    <state>8</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceJtagDeviceBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceJtagDeviceAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceJtagInstrBitsBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceJtagInstrBitsAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIceDaisyChain</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagDebugTimers</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OATMELICEJtagDebugEeprom</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagDebugFuses</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagIcedownloadToData</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEJtagSoftwareBreak</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ExitBreakpointP7</name>
                    <state>0</state>
                </option>
                <option>
                    <name>PutcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GetcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OATMELICECommunication</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICECommunicationUsbEditId</name>
                    <state></state>
                </option>
                <option>
                    <name>OATMELICEDebugPort</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICEDebugWireDebugPort</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OATMELICEAVRJtagIcePreserveFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OATMELICETPIDebugPort</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OATMELICEUPDIDebugPort</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>AVRONE</name>
            <archiveVersion>4</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>OAVRONEDriver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OAVRONEExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>OAVRONEExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONELogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceSuppLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceConsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceJtagFreqRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceJtagFreqManually</name>
                    <state>100</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceJtagFreq</name>
                    <version>0</version>
                    <state>8</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceJtagDeviceBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceJtagDeviceAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceJtagInstrBitsBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceJtagInstrBitsAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIceDaisyChain</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagDebugTimers</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OAVRONEJtagDebugEeprom</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagDebugReset</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagDebugFuses</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagIcedownloadToData</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEJtagSoftwareBreak</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ExitBreakpointP7</name>
                    <state>0</state>
                </option>
                <option>
                    <name>PutcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GetcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OAVRONECommunication</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONECommunicationUsbEditId</name>
                    <state></state>
                </option>
                <option>
                    <name>OAVRONEDebugPort</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OAVRONEDebugWireDebugPort</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OAVRONEAVRJtagIcePreserveFlash</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>JTAGICE3AVR</name>
            <archiveVersion>6</archiveVersion>
            <data>
                <version>7</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>OJTAGICE3Driver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICE3ExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>OJTAGICE3ExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceSuppLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceConsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceJtagFreqRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceJtagFreqManually</name>
                    <state>100</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceJtagFreq</name>
                    <version>0</version>
                    <state>8</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceJtagDeviceBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceJtagDeviceAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceJtagInstrBitsBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceJtagInstrBitsAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIceDaisyChain</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagDebugTimers</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagDebugEeprom</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagDebugFuses</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagIcedownloadToData</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3JtagSoftwareBreak</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ExitBreakpointP7</name>
                    <state>0</state>
                </option>
                <option>
                    <name>PutcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GetcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICE3Communication</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3CommunicationUsbEditId</name>
                    <state></state>
                </option>
                <option>
                    <name>OJTAGICE3DebugPort</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICE3DebugWireDebugPort</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICE3AVRJtagIcePreserveFlash</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>JTAGICEMKIIAVR</name>
            <archiveVersion>5</archiveVersion>
            <data>
                <version>7</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>OJTAGICEMKIIAVRDriver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRPort</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRBaud</name>
                    <version>0</version>
                    <state>5</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRParity</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRDataBits</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRStopBits</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRHandshake</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRAllComm</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceDefaultCom</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceComPort</name>
                    <version>0</version>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceSuppLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceConsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceJtagFreqRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceJtagFreqManually</name>
                    <state>100000</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceJtagFreq</name>
                    <version>0</version>
                    <state>8</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceJtagDeviceBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceJtagDeviceAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceJtagInstrBitsBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceJtagInstrBitsAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIceDaisyChain</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagDebugTimers</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagDebugEeprom</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagDebugReset</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagDebugFuses</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIcedownloadToData</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagSoftwareBreak</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ExitBreakpointP7</name>
                    <state>0</state>
                </option>
                <option>
                    <name>PutcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GetcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRCommunicationNew</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRCommunicationUsbEditId</name>
                    <state></state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRUsePDI</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIOnlyPDI</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OJTAGICEMKIIAVRJtagIcePreserveFlash</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>DRAGONAVR</name>
            <archiveVersion>3</archiveVersion>
            <data>
                <version>3</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>ODRAGONAVRDriver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>ODRAGONAVRExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>ODRAGONAVRExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceSuppLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceConsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceJtagFreqRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceJtagFreqManually</name>
                    <state>100000</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceJtagFreq</name>
                    <version>0</version>
                    <state>8</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceJtagDeviceBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceJtagDeviceAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceJtagInstrBitsBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceJtagInstrBitsAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIceDaisyChain</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagDebugTimers</name>
                    <state>1</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagDebugEeprom</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagDebugReset</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagDebugFuses</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIcedownloadToData</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagSoftwareBreak</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ExitBreakpointP7</name>
                    <state>0</state>
                </option>
                <option>
                    <name>PutcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GetcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>ODRAGONAVRCommunicationNew</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONAVRCommunicationUsbEditId</name>
                    <state></state>
                </option>
                <option>
                    <name>ODRAGONAVRUsePDI</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ODRAGONOnlyPDI</name>
                    <state>1</state>
                </option>
                <option>
                    <name>ODRAGONAVRJtagIcePreserveFlash</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>POWERDEBUGGERAVR</name>
            <archiveVersion>7</archiveVersion>
            <data>
                <version>4</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>OPOWERDEBUGGERDriver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERDoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERLogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceSuppLoad</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceConsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceJtagFreqRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceJtagFreqManually</name>
                    <state>100</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceJtagFreq</name>
                    <version>0</version>
                    <state>8</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceJtagDeviceBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceJtagDeviceAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceJtagInstrBitsBefore</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceJtagInstrBitsAfter</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIceDaisyChain</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagDebugTimers</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagDebugEeprom</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagDebugFuses</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagIcedownloadToData</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERJtagSoftwareBreak</name>
                    <state>0</state>
                </option>
                <option>
                    <name>ExitBreakpointP7</name>
                    <state>0</state>
                </option>
                <option>
                    <name>PutcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GetcharBreakpointP7</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERCommunication</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERCommunicationUsbEditId</name>
                    <state></state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERDebugPort</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERDebugWireDebugPort</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERAVRJtagIcePreserveFlash</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERTPIDebugPort</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OPOWERDEBUGGERUPDIDebugPort</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>SIMAVR</name>
            <archiveVersion>2</archiveVersion>
            <data>
                <version>1</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>OSIMAVRDriver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OSIMAVRExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>OSIMAVRExtraOptionsCheck</name>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>THIRDPARTYAVR</name>
            <archiveVersion>2</archiveVersion>
            <data>
                <version>1</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>0</debug>
                <option>
                    <name>OTHIRDPARTYAVRDriver</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OTHIRDPARTYAVRExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>OTHIRDPARTYAVRExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OTHIRDPARTYAVRDriverDll</name>
                    <state>Browse to your Third party driver</state>
                </option>
                <option>
                    <name>OTHIRDPARTYAVRSuppress</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OTHIRDPARTYAVRVerify</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OTHIRDPARTYAVRLogFileCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OTHIRDPARTYAVRLogFileEditB</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
            </data>
        </settings>
        <debuggerPlugins>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-286-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-III\uCOS-III-KA-CSpy.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\Stk600\Stk600Plugin.ewplugin</file>
                <loadFlag>1</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\TargetAccessServer\TargetAccessServer.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\uCProbe\uCProbePlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
        </debuggerPlugins>
    </configuration>
</project>
