<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RTOSDemo.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>RTOSDemo</project>
        <configuration>NOR Debug</configuration>
      </member>
      <member>
        <project>RTOSDemo</project>
        <configuration>RAM Debug</configuration>
      </member>
      <member>
        <project>RTOSDemo</project>
        <configuration>SerialFlash Debug</configuration>
      </member>
      <member>
        <project>RTOSDemo</project>
        <configuration>SerialFlash for Bootloader</configuration>
      </member>
      <member>
        <project>Bootloader</project>
        <configuration>SerialFlash Bootloader</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


