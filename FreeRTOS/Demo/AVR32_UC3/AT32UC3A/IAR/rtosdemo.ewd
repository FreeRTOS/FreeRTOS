<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>1</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>AVR32</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>CCore</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>CRunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CMacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CMacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>JTAGICEMKIIAVR32</state>
        </option>
        <option>
          <name>DDFOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DDFFile</name>
          <state>$TOOLKIT_DIR$\config\iouc3a0512.ddf</state>
        </option>
        <option>
          <name>DebuggerUseUbrofResetVector</name>
          <state>0</state>
        </option>
        <option>
          <name>IExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>IExtraOptions</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>JTAGICEMKIIAVR32</name>
      <archiveVersion>3</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CJtagIceMkIIMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CJtagIceMkIIPeripherals</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIReset</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIISWBreakpoints</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIISuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIVerifyDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>CJTagIceMkIICommunicationLogging</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIICommLogFile</name>
          <state></state>
        </option>
        <option>
          <name>CJtagIceMkIIConnectionRage</name>
          <version>0</version>
          <state>2</state>
        </option>
        <option>
          <name>CJtagIceMkIIConnectionPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIJtagFrequence</name>
          <version>0</version>
          <state>8</state>
        </option>
        <option>
          <name>CJtagIceMkIIDaisyChain</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIDaisyChainBeforeDevices</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIDaisyChainBeforeBits</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIDaisyChainAfterDevices</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIDaisyChainAfterBits</name>
          <state>0</state>
        </option>
        <option>
          <name>FlashLoaders</name>
          <state></state>
        </option>
        <option>
          <name>UseFlashLoader</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMAVR32</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CSimMandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>AVR32</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>CCore</name>
          <state>0</state>
        </option>
        <option>
          <name>CRunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>CRunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>CMacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>CMacFile</name>
          <state></state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>JTAGICEMKIIAVR32</state>
        </option>
        <option>
          <name>DDFOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>DDFFile</name>
          <state>$TOOLKIT_DIR$\config\iouc3a0512.ddf</state>
        </option>
        <option>
          <name>DebuggerUseUbrofResetVector</name>
          <state>0</state>
        </option>
        <option>
          <name>IExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>IExtraOptions</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>JTAGICEMKIIAVR32</name>
      <archiveVersion>3</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CJtagIceMkIIMandatory</name>
          <state>1</state>
        </option>
        <option>
          <name>CJtagIceMkIIPeripherals</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIReset</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIISWBreakpoints</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIISuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIVerifyDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>CJTagIceMkIICommunicationLogging</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIICommLogFile</name>
          <state></state>
        </option>
        <option>
          <name>CJtagIceMkIIConnectionRage</name>
          <version>0</version>
          <state>2</state>
        </option>
        <option>
          <name>CJtagIceMkIIConnectionPort</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIJtagFrequence</name>
          <version>0</version>
          <state>8</state>
        </option>
        <option>
          <name>CJtagIceMkIIDaisyChain</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIDaisyChainBeforeDevices</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIDaisyChainBeforeBits</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIDaisyChainAfterDevices</name>
          <state>0</state>
        </option>
        <option>
          <name>CJtagIceMkIIDaisyChainAfterBits</name>
          <state>0</state>
        </option>
        <option>
          <name>FlashLoaders</name>
          <state></state>
        </option>
        <option>
          <name>UseFlashLoader</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>SIMAVR32</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CSimMandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
</project>


