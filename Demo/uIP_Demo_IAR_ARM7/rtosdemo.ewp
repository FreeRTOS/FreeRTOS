# IAR project rtosdemo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: AT91SAM7X256 Atmel AT91SAM7X256
  ICCARM.CCDefines: SAM7_IAR
  ICCARM.CCDiagSuppress: pe815, pe191, pa082, pe167, pa050
  ICCARM.CCIncludePath2: ..\..\source\portable\iar\AtmelSAM7S64; ..\common\include; ..\..\source\include; SrcIAR; $PROJ_DIR$; uip; emac
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: srciar\; ..\..\include\; ..\common\include; ..\..\Source\include; ..\..\Source\portable\IAR\AtmelSAM7S64
  OBJCOPY.OOCOutputFile: rtosdemo.srec
  ILINK.IlinkOutputFile: rtosdemo.out
  ILINK.IlinkIcfFile: resource\at91SAM7X256_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    SrcIAR/: Cstartup.s Cstartup_SAM7.c
  group Demo Source
    ../Common/Minimal/: BlockQ.c death.c dynamic.c flash.c flop.c integer.c PollQ.c semtest.c
    EMAC/: EMAClISR.s79 SAM7_EMAC.c
    ../../Source/portable/MemMang/: heap_2.c
    ./: main.c uIP_Task.c
    ParTest/: ParTest.c
  group FreeRTOS Source
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/AtmelSAM7S64/: port.c portasm.s79
  group uIP Source
    uip/: uip.c uip_arch.c uip_arp.c
  group uIP Source/http
    uip/: cgi.c fs.c httpd.c
