# IAR project RTOSDemo.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F100LE RL78 - R5F100LE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 130
  General.GenNearHeapSize: 0
  General.GenFarHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCDiagSuppress: Pa082
  ICCRL78.CCIncludePath2: ..\..\Source\include; ..\Common\include; $PROJ_DIR$; ..\..\Source\portable\IAR\RL78
  ARL78.AsmIncludePath: ..\..\Source\portable\IAR\RL78; $PROJ_DIR$
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkr5f100le.xcl
  XLINK.XlinkStackSize: 1
  group Demo Source
    ./: main.c RegTest.s87
  group Demo Source/StandardDemos
    ../Common/Minimal/: blocktim.c dynamic.c PollQ.c
  group Kernel Source
    ../../Source/portable/MemMang/: heap_1.c
    ../../Source/: list.c queue.c tasks.c timers.c
    ../../Source/portable/IAR/RL78/: port.c portasm.s87
