# IAR project RTOSDemo.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F571ML R5F571ML
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x300
  General.IStackSize: 0x300
  General.HeapSize: 0x4
  ICCRX.CCDefines: __RX
  ICCRX.CCIncludePath2: src\cg_src; src; ..\..\Source\include; ..\..\Source\portable\IAR\RXv2; ..\Common\include; src\Full_Demo; ..\..\..\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\; src
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  General.OGChipSelectMenu: RX600 Generic RX600
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: NDEBUG
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  group (top)
    src/: FreeRTOSConfig.h main.c rskrx71mdef.h
    src/cg_src/: r_cg_intprg_iar.c
  group Blinky_Demo
    src/Blinky_Demo/: main_blinky.c
  group cg_src
    src/cg_src/: r_cg_cgc.c r_cg_hardware_setup.c r_cg_icu.c r_cg_port.c r_cg_sci.c r_cg_sci_user_iar.c
  group FreeRTOS_Source
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/portable
    ../../Source/portable/IAR/RXv2/: port.c port_asm.s
  group FreeRTOS_Source/portable/MemMang
    ../../Source/portable/MemMang/: heap_4.c
  group Full_Demo
    src/Full_Demo/: IntQueueTimer.c main_full.c RegTest_IAR.s
    ../../../FreeRTOS-Plus/Demo/Common/FreeRTOS_Plus_CLI_Demos/: Sample-CLI-commands.c UARTCommandConsole.c
  group Full_Demo/FreeRTOS+CLI
    ../../../FreeRTOS-Plus/Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
  group Full_Demo/Standard_Demo_Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c IntQueue.c IntSemTest.c QueueOverwrite.c recmutex.c semtest.c TaskNotify.c TimerDemo.c
