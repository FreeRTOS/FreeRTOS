# Keil uVision project RTOSDemo.uvproj, settings and files
target XMC1300 (ARM-ADS)
  device: XMC1302-200 Infineon
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x10001000-0x10032FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: RTOSDemo
  c flags: Optim=1
  c include: ..\CORTEX_M0_Infineon_Boot_Kits_IAR_Keil;..\..\Source\include;..\..\Source\portable\RVDS\ARM_CM0;..\Common\include
  memory RVCT4: ROM 0x10001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group System
    ./System_Keil/: system_XMC1300.c system_XMC1100.c system_XMC1200.c
  group FreeRTOS source
    ../../Source/: timers.c list.c queue.c tasks.c
    ../../Source/portable/RVDS/ARM_CM0/: port.c
    ../../Source/portable/MemMang/: heap_4.c
  group Demo App Source
    ./: main.c main-blinky.c FreeRTOSConfig.h main-full.c RegTest.s ParTest_XMC1200.c
  group Common Demo Tasks
    ../Common/Minimal/: dynamic.c recmutex.c blocktim.c countsem.c
target XMC1200 (ARM-ADS)
  device: XMC1200-200 Infineon
  cpu: as above
  output: RTOSDemo
  c flags: Optim=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x4000
