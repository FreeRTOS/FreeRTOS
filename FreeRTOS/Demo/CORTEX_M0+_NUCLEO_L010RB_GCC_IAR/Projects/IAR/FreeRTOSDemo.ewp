# IAR project FreeRTOSDemo.ewp, settings and files
configuration FreeRTOSDemo (ARM, debug)
  General.OGChipSelectEditMenu: STM32L010RB ST STM32L010RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L010xB
  ICCARM.IExtraOptions: --diag_suppress Pa082
  ICCARM.CCIncludePath2: ../../ST_Code/Core/Inc; ../../ST_Code/Drivers/STM32L0xx_HAL_Driver/Inc; ../../ST_Code/Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../../ST_Code/Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../ST_Code/Drivers/CMSIS/Include; ../../Config; ../../Demo; ../../../Common/include; ../../../../Source/include; ../../../../Source/portable/GCC/ARM_CM0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc; ..\..\Config
  OBJCOPY.OOCOutputFile: FreeRTOSDemo.hex
  ILINK.IlinkOutputFile: FreeRTOSDemo.out
  ILINK.IlinkIcfFile: stm32l010xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Config
    ../../Config/: FreeRTOSConfig.h
  group Demo
    ../../Demo/: app_main.c app_main.h main_blinky.c main_full.c RegTests.c RegTests.h
  group Demo/IAR
    ../../Demo/IAR/: RegTestAsm.S
  group Demo/Standard_Demos
    ../../../Common/Minimal/: AbortDelay.c BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c integer.c IntSemTest.c MessageBufferAMP.c MessageBufferDemo.c PollQ.c QPeek.c QueueOverwrite.c QueueSet.c QueueSetPolling.c recmutex.c semtest.c StaticAllocation.c StreamBufferDemo.c StreamBufferInterrupt.c TaskNotify.c TaskNotifyArray.c TimerDemo.c
  group FreeRTOS
    ../../../../Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/include
    ../../../../Source/include/: atomic.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/portable/IAR/ARM_CM0
    ../../../../Source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group FreeRTOS/portable/MemMang
    ../../../../Source/portable/MemMang/: heap_4.c
  group ST_Code/Core/Inc
    ../../ST_Code/Core/Inc/: main.h stm32l0xx_hal_conf.h stm32l0xx_it.h
  group ST_Code/Core/Src
    ../../ST_Code/Core/Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_hal_timebase_tim.c stm32l0xx_it.c system_stm32l0xx.c
  group ST_Code/Drivers/CMSIS/Device/ST/STM32L0xx/Include
    ../../ST_Code/Drivers/CMSIS/Device/ST/STM32L0xx/Include/: stm32l010xb.h stm32l0xx.h system_stm32l0xx.h
  group ST_Code/Drivers/CMSIS/Include
    ../../ST_Code/Drivers/CMSIS/Include/: cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm0plus.h
  group ST_Code/Drivers/STM32L0xx_HAL_Driver/Inc
    ../../ST_Code/Drivers/STM32L0xx_HAL_Driver/Inc/: stm32l0xx_hal.h stm32l0xx_hal_cortex.h stm32l0xx_hal_def.h stm32l0xx_hal_dma.h stm32l0xx_hal_exti.h stm32l0xx_hal_flash.h stm32l0xx_hal_flash_ex.h stm32l0xx_hal_flash_ramfunc.h stm32l0xx_hal_gpio.h stm32l0xx_hal_gpio_ex.h stm32l0xx_hal_i2c.h stm32l0xx_hal_i2c_ex.h stm32l0xx_hal_pwr.h stm32l0xx_hal_pwr_ex.h stm32l0xx_hal_rcc.h stm32l0xx_hal_rcc_ex.h stm32l0xx_hal_tim.h stm32l0xx_hal_tim_ex.h stm32l0xx_hal_uart.h stm32l0xx_hal_uart_ex.h
  group ST_Code/Drivers/STM32L0xx_HAL_Driver/Inc/Legacy
    ../../ST_Code/Drivers/STM32L0xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group ST_Code/Drivers/STM32L0xx_HAL_Driver/Src
    ../../ST_Code/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Startup
    ./: startup_stm32l010xb.s
