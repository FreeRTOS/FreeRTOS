# IAR project RTOSDemo.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.GHeapSize: 8
  General.GStackSize: 80
  General.OGChipSelectMenu: MSP430F449 MSP430F449
  ICC430.CCDefines: IAR_MSP430
  ICC430.CCDiagSuppress: pa082,pe191
  ICC430.newCCIncludePaths: ..\..\Source\include; ..\Common\include; $PROJ_DIR$
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F449.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GHeapSize: 80
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group Demo Source
    ../Common/Minimal/: comtest.c flash.c integer.c PollQ.c
    ../../Source/portable/MemMang/: heap_1.c
    ./: main.c
    ParTest/: ParTest.c
    serial/: serial.c serialASM.s43
  group FreeRTOS Source
    ../../Source/: croutine.c list.c queue.c tasks.c
    ../../Source/portable/IAR/MSP430/: port.c portext.s43
