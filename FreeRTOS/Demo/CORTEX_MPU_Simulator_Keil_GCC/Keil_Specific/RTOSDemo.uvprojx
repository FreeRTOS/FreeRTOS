# Keil uVision project RTOSDemo.uvprojx, settings and files
target RTOSDemo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: RTOSDemo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..;..\..\..\Source\include;..\..\..\Source\portable\RVDS\ARM_CM4_MPU;..\..\Common\include;..\CMSIS;..\main_full
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: RTOSDemo.sct
  group System
    ./: startup_MPS_CM4.S
  group main_and_config
    ../: main.c FreeRTOSConfig.h
    ./: RegTest.c
  group FreeRTOS_Source
    ../../../Source/: event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../../Source/portable/MemMang/: heap_4.c
    ../../../Source/portable/RVDS/ARM_CM4_MPU/: port.c mpu_wrappers_v2_asm.c
    ../../../Source/portable/Common/: mpu_wrappers.c mpu_wrappers_v2.c
