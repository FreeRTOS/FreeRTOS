# Keil uVision project RTOSDemo.uvprojx, settings and files
target SRAM (ARM-ADS)
  device: SAMV71Q21 Atmel
  pack: Atmel.SAMV7.1.0.0
  cpu: IROM(0x00000000,0x200000) IRAM(0x20400000,0x60000) CPUTYPE("Cortex-M7") FPU2 CLOCK(12000000) ELITTLE
  output: RTOSDemo
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __SAMV71Q21__, NDEBUG
  c include: .\;.\libchip_samv7\include\cmsis\CMSIS;.\libboard_samv7-ek;.\libchip_samv7;.\libboard_samv7-ek\include;.\libchip_samv7\include\samv7;..\..\Source\include;..\RTOSDemo;..\..\Source\portable\RVDS\ARM_CM7\r0p1;..\Common\include;.\Full_Demo
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x40000
  scatter file: .\libboard_samv7-ek\resources\mdk\sram.sct
  group Atmel_Libboard
    ./libboard_samv7-ek/source/: board_lowlevel.c led.c dbg_console.c
    ./libboard_samv7-ek/resources/mdk/: startup_sam.c workaround.s
    ./libboard_samv7-ek/resources/: system_sam.c
  group Source
    ./: main.c FreeRTOSConfig.h
    ./Full_Demo/: main_full.c RegTest.c IntQueueTimer.c
    ./Blinky_Demo/: main_blinky.c
  group Atmel_Libchip
    ./libchip_samv7/source/: pio.c pmc.c tc.c wdt.c supc.c pio_capture.c
  group FreeRTOS_Source
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Common_Demo_Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c QueueOverwrite.c QueueSet.c recmutex.c semtest.c TaskNotify.c TimerDemo.c IntQueue.c IntSemTest.c
software components: CMSIS:CORE 3.40.0
