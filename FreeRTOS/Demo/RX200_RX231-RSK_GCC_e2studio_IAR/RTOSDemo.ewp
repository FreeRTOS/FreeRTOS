# IAR project RTOSDemo.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F52318 R5F52318
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x300
  General.IStackSize: 0x300
  General.HeapSize: 0x04
  ICCRX.CCIncludePath2: src; src\cg_src; ..\..\Source\include; ..\..\Source\portable\IAR\RXv2; ..\Common\include; src\Full_Demo
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\; src
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: src\IAR_Support\lnkr5f52318.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  General.OGChipSelectMenu: RX600 Generic RX600
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: NDEBUG
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  group (top)
    src/: main.c rskrx231def.h
  group Blinky_Demo
    src/Blinky_Demo/: main_blinky.c
  group cg_src
    src/cg_src/: r_cg_cgc.c r_cg_hardware_setup.c r_cg_icu.c r_cg_macrodriver.h r_cg_port.c
  group FreeRTOS_Source
    ../../Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/portable/MemMang
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/IAR/RXv2/: port.c port_asm.s
  group Full_Demo
    src/Full_Demo/: IntQueueTimer.c main_full.c RegTest_IAR.s
  group Full_Demo/Standard_Demo_Tasks
    ../Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c IntQueue.c IntSemTest.c QueueOverwrite.c recmutex.c semtest.c TaskNotify.c TimerDemo.c
  group System
    src/IAR_Support/: defaults.s exceptvect_rxv2.s option_rom_rxv2.s
