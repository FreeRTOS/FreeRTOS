# IAR project RTOSDemo_IAR.ewp, settings and files
configuration Blinky (ARM, debug)
  General.OGChipSelectEditMenu: MB9AF314L Fujitsu MB9AF314L
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: Fujitu_source; $PROJ_DIR$; ../../Source/include; ../../Source/portable/IAR/ARM_CM3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTOSDemo_IAR.srec
  ILINK.IlinkOutputFile: RTOSDemo_IAR.out
  ILINK.IlinkIcfFile: config\mb9af314.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Full (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: Fujitu_source; $PROJ_DIR$; ../../Source/include; ../../Source/portable/IAR/ARM_CM3; ../common/include
configuration Full_with_optimisation (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main-full.c main_blinky.c ParTest.c serial.c
  group Common_Demo_Source
    ../Common/Minimal/: BlockQ.c blocktim.c comtest.c countsem.c death.c dynamic.c flash.c GenQTest.c PollQ.c QPeek.c recmutex.c semtest.c TimerDemo.c
  group FreeRTOS_Source
    ../../Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/Portable
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Fujitsu_Source
    Fujitu_source/: core_cm3.c system_mb9af31x.c
    Fujitu_source/startup_iar/: startup_mb9af31x.s
