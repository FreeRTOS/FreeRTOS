# IAR project RTOSDemo.ewp, settings and files
configuration Full (ARM, debug)
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60N512
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\Source\include; ..\..\Source\portable\IAR\ARM_CM3; ..\Common\include; Freescale_Code\common; Freescale_Code\cpu; Freescale_Code\drivers\uart; Freescale_Code\drivers\mcg; Freescale_Code\drivers\wdog; Freescale_Code\drivers\adc16
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: Freescale_Code\common\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Blinky (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: FreeRTOSConfig.h main-full.c main_blinky.c ParTest.c
  group Common_Demo_Files
    ../Common/Minimal/: BlockQ.c blocktim.c comtest.c countsem.c death.c dynamic.c GenQTest.c PollQ.c QPeek.c recmutex.c semtest.c TimerDemo.c
  group FreeRTOS_Source
    ../../Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/portable
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Freescale_Code/common
    Freescale_Code/common/: startup.c
  group Freescale_Code/cpu
    Freescale_Code/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group Freescale_Code/drivers/mcg
    Freescale_Code/drivers/mcg/: mcg.c
  group Freescale_Code/drivers/uart
    Freescale_Code/drivers/uart/: uart.c
  group Freescale_Code/drivers/wdog
    Freescale_Code/drivers/wdog/: wdog.c
